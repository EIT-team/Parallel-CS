File: schematics/Connector.Filter.Board/Connector.Board.sch (EAGLE design)
At the start: 220 parts, among them U1 AD8244, U10 AD8244, U11 AD8244, U12 AD8244, U13 AD8244, U14 AD8244, U15 AD8244, U16 AD8244, U17 AD8244, U18 AD8244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

Commit message: Finished Board
Parts:
- J1: value (none) -> V+BATT
- J2: value (none) -> V-BATT
- JP1: value (none) -> Batt1_backup
- JP2: value (none) -> Batt2_backup
- JP3: value (none) -> Batt2_SW
- JP4: value (none) -> Batt1_SW
- LED1, LED2: value (none) -> RED
Other:
- moved on the sheet: J1, JP1, JP3, JP4
Changed lines of the file:
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@@
 <layer number="20" name="Dimension" color="15" fill="1" visible="yes" active="no"/>
 <layer number="21" name="tPlace" color="7" fill="1" visible="yes" active="no"/>
-<layer number="22" name="bPlace" color="7" fill="1" visible="yes" active="no"/>
+<layer number="22" name="bPlace" color="14" fill="1" visible="yes" active="no"/>
 <layer number="23" name="tOrigins" color="15" fill="1" visible="yes" active="no"/>
 <layer number="24" name="bOrigins" color="15" fill="1" visible="yes" active="no"/>
 <layer number="25" name="tNames" color="7" fill="1" visible="yes" active="no"/>
-<layer number="26" name="bNames" color="7" fill="1" visible="yes" active="no"/>
+<layer number="26" name="bNames" color="14" fill="1" visible="yes" active="no"/>
 <layer number="27" name="tValues" color="7" fill="1" visible="yes" active="no"/>
 <layer number="28" name="bValues" color="7" fill="1" visible="yes" active="no"/>
@@
 <layer number="50" name="dxf" color="7" fill="1" visible="yes" active="no"/>
 <layer number="51" name="tDocu" color="7" fill="1" visible="yes" active="no"/>
-<layer number="52" name="bDocu" color="7" fill="1" visible="yes" active="no"/>
+<layer number="52" name="bDocu" color="14" fill="1" visible="yes" active="no"/>
 <layer number="53" name="tGND_GNDA" color="7" fill="9" visible="yes" active="no"/>
 <layer number="54" name="bGND_GNDA" color="1" fill="9" visible="yes" active="no"/>
@@
 <part name="TP31" library="connector_board_lib" deviceset="TOUCHPROOF" device=""/>
 <part name="TP32" library="connector_board_lib" deviceset="TOUCHPROOF" device=""/>
-<part name="JP1" library="pinhead" deviceset="PINHD-1X2" device=""/>
-<part name="JP2" library="pinhead" deviceset="PINHD-1X2" device=""/>
+<part name="JP1" library="pinhead" deviceset="PINHD-1X2" device="" value="Batt1_backup"/>
+<part name="JP2" library="pinhead" deviceset="PINHD-1X2" device="" value="Batt2_backup"/>
 <part name="SUPPLY3" library="supply2" deviceset="GND" device=""/>
 <part name="SUPPLY4" library="supply2" deviceset="GND" device=""/>
@@
 <part name="R24" library="resistor" deviceset="R-EU_" device="R0402" value="1M"/>
 <part name="GND24" library="supply1" deviceset="GND" device=""/>
-<part name="J1" library="SparkFun-Connectors" deviceset="JST_2MM_MALE" device=""/>
-<part name="J2" library="SparkFun-Connectors" deviceset="JST_2MM_MALE" device=""/>
-<part name="JP4" library="pinhead" deviceset="PINHD-2X2" device=""/>
-<part name="JP3" library="pinhead" deviceset="PINHD-2X2" device=""/>
-<part name="LED1" library="led" deviceset="LED" device="SML0805"/>
-<part name="LED2" library="led" deviceset="LED" device="SML0805"/>
+<part name="J1" library="SparkFun-Connectors" deviceset="JST_2MM_MALE" device="" value="V+BATT"/>
+<part name="J2" library="SparkFun-Connectors" deviceset="JST_2MM_MALE" device="" value="V-BATT"/>
+<part name="JP4" library="pinhead" deviceset="PINHD-2X2" device="" value="Batt1_SW"/>
+<part name="JP3" library="pinhead" deviceset="PINHD-2X2" device="" value="Batt2_SW"/>
+<part name="LED1" library="led" deviceset="LED" device="SML0805" value="RED"/>
+<part name="LED2" library="led" deviceset="LED" device="SML0805" value="RED"/>
 <part name="R65" library="resistor" deviceset="R-EU_" device="R0402" value="1k"/>
 <part name="SUPPLY1" library="supply2" deviceset="GND" device=""/>
@@
 </plain>
 <instances>
-<instance part="JP1" gate="G$1" x="-101.6" y="109.22"/>
+<instance part="JP1" gate="G$1" x="-101.6" y="114.3"/>
 <instance part="JP2" gate="G$1" x="-101.6" y="96.52"/>
-<instance part="SUPPLY3" gate="GND" x="-76.2" y="101.6" rot="R180"/>
-<instance part="SUPPLY4" gate="GND" x="-60.96" y="104.14"/>
+<instance part="SUPPLY3" gate="GND" x="-60.96" y="101.6" rot="R180"/>
+<instance part="SUPPLY4" gate="GND" x="-60.96" y="109.22"/>
 <instance part="C83" gate="G$1" x="-30.48" y="116.84"/>
 <instance part="C84" gate="G$1" x="-30.48" y="88.9"/>
@@
 <instance part="C82" gate="G$1" x="-38.1" y="88.9"/>
 <instance part="C86" gate="G$1" x="-22.86" y="88.9"/>
-<instance part="J1" gate="G$1" x="-121.92" y="109.22" rot="R90"/>
+<instance part="J1" gate="G$1" x="-121.92" y="114.3" rot="R90"/>
 <instance part="J2" gate="G$1" x="-121.92" y="96.52" rot="R90"/>
-<instance part="JP4" gate="A" x="-71.12" y="109.22"/>
-<instance part="JP3" gate="A" x="-86.36" y="96.52"/>
+<instance part="JP4" gate="A" x="-71.12" y="114.3"/>
+<instance part="JP3" gate="A" x="-71.12" y="96.52"/>
 <instance part="LED1" gate="G$1" x="-99.06" y="78.74"/>
 <instance part="LED2" gate="G$1" x="-86.36" y="66.04" rot="R180"/>
@@
 <net name="V-" class="0">
 <segment>
-<wire x1="-76.2" y1="96.52" x2="-76.2" y2="93.98" width="0.1524" layer="91"/>
-<label x="-76.2" y="93.98" size="1.778" layer="95"/>
+<wire x1="-60.96" y1="96.52" x2="-60.96" y2="93.98" width="0.1524" layer="91"/>
+<label x="-60.96" y="93.98" size="1.778" layer="95"/>
 <pinref part="JP3" gate="A" pin="4"/>
-<wire x1="-83.82" y1="96.52" x2="-76.2" y2="96.52" width="0.1524" layer="91"/>
+<wire x1="-68.58" y1="96.52" x2="-60.96" y2="96.52" width="0.1524" layer="91"/>
 </segment>
 <segment>
@@
 <net name="V+" class="0">
 <segment>
-<wire x1="-60.96" y1="111.76" x2="-60.96" y2="114.3" width="0.1524" layer="91"/>
-<label x="-60.96" y="114.3" size="1.778" layer="95"/>
+<wire x1="-60.96" y1="116.84" x2="-60.96" y2="119.38" width="0.1524" layer="91"/>
+<label x="-60.96" y="119.38" size="1.778" layer="95"/>
 <pinref part="JP4" gate="A" pin="2"/>
-<wire x1="-68.58" y1="111.76" x2="-60.96" y2="111.76" width="0.1524" layer="91"/>
+<wire x1="-68.58" y1="116.84" x2="-60.96" y2="116.84" width="0.1524" layer="91"/>
 </segment>
 <segment>
@@
 </segment>
 <segment>
-<wire x1="-66.04" y1="109.22" x2="-60.96" y2="109.22" width="0.1524" layer="91"/>
+<wire x1="-66.04" y1="114.3" x2="-60.96" y2="114.3" width="0.1524" layer="91"/>
 <pinref part="SUPPLY4" gate="GND" pin="GND"/>
-<wire x1="-60.96" y1="109.22" x2="-60.96" y2="106.68" width="0.1524" layer="91"/>
+<wire x1="-60.96" y1="114.3" x2="-60.96" y2="111.76" width="0.1524" layer="91"/>
 <pinref part="JP4" gate="A" pin="4"/>
-<wire x1="-66.04" y1="109.22" x2="-68.58" y2="109.22" width="0.1524" layer="91"/>
+<wire x1="-66.04" y1="114.3" x2="-68.58" y2="114.3" width="0.1524" layer="91"/>
 </segment>
 <segment>
 <pinref part="JP3" gate="A" pin="2"/>
 <pinref part="SUPPLY3" gate="GND" pin="GND"/>
-<wire x1="-83.82" y1="99.06" x2="-76.2" y2="99.06" width="0.1524" layer="91"/>
+<wire x1="-68.58" y1="99.06" x2="-60.96" y2="99.06" width="0.1524" layer="91"/>
 </segment>
 <segment>
@@
 <pinref part="J1" gate="G$1" pin="+"/>
 <pinref part="JP1" gate="G$1" pin="1"/>
-<wire x1="-116.84" y1="111.76" x2="-104.14" y2="111.76" width="0.1524" layer="91"/>
-<label x="-116.84" y="111.76" size="1.778" layer="95"/>
+<wire x1="-116.84" y1="116.84" x2="-104.14" y2="116.84" width="0.1524" layer="91"/>
+<label x="-116.84" y="116.84" size="1.778" layer="95"/>
 <pinref part="JP4" gate="A" pin="1"/>
-<wire x1="-104.14" y1="111.76" x2="-76.2" y2="111.76" width="0.1524" layer="91"/>
-<junction x="-104.14" y="111.76"/>
+<wire x1="-104.14" y1="116.84" x2="-76.2" y2="116.84" width="0.1524" layer="91"/>
+<junction x="-104.14" y="116.84"/>
 </segment>
 </net>
@@
 <pinref part="J1" gate="G$1" pin="-"/>
 <pinref part="JP1" gate="G$1" pin="2"/>
-<wire x1="-116.84" y1="109.22" x2="-104.14" y2="109.22" width="0.1524" layer="91"/>
-<label x="-116.84" y="109.22" size="1.778" layer="95"/>
+<wire x1="-116.84" y1="114.3" x2="-104.14" y2="114.3" width="0.1524" layer="91"/>
+<label x="-116.84" y="114.3" size="1.778" layer="95"/>
 <pinref part="JP4" gate="A" pin="3"/>
-<wire x1="-104.14" y1="109.22" x2="-76.2" y2="109.22" width="0.1524" layer="91"/>
-<junction x="-104.14" y="109.22"/>
+<wire x1="-104.14" y1="114.3" x2="-76.2" y2="114.3" width="0.1524" layer="91"/>
+<junction x="-104.14" y="114.3"/>
 </segment>
 </net>
@@
 <label x="-116.84" y="99.06" size="1.778" layer="95"/>
 <pinref part="JP3" gate="A" pin="1"/>
-<wire x1="-104.14" y1="99.06" x2="-91.44" y2="99.06" width="0.1524" layer="91"/>
+<wire x1="-104.14" y1="99.06" x2="-76.2" y2="99.06" width="0.1524" layer="91"/>
 <junction x="-104.14" y="99.06"/>
 </segment>
@@
 <label x="-116.84" y="96.52" size="1.778" layer="95"/>
 <pinref part="JP3" gate="A" pin="3"/>
-<wire x1="-104.14" y1="96.52" x2="-91.44" y2="96.52" width="0.1524" layer="91"/>
+<wire x1="-104.14" y1="96.52" x2="-76.2" y2="96.52" width="0.1524" layer="91"/>
 <junction x="-104.14" y="96.52"/>
 </segment>

Commit message: fixed wrong orientation on -ve led
Connections:
- removed net N$11: LED2.C, R66.1
- new net N$1: LED2.A, R66.1
- net V-: now also LED2.C; no longer LED2.A
Other:
- moved on the sheet: LED2
Changed lines of the file:
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@@
 <grid distance="0.1" unitdist="inch" unit="inch" style="lines" multiple="1" display="no" altdistance="0.01" altunitdist="inch" altunit="inch"/>
 <layers>
-<layer number="1" name="Top" color="4" fill="1" visible="yes" active="no"/>
-<layer number="2" name="Route2" color="13" fill="1" visible="yes" active="no"/>
-<layer number="3" name="Route3" color="4" fill="3" visible="yes" active="no"/>
-<layer number="4" name="Route4" color="1" fill="4" visible="yes" active="no"/>
-<layer number="5" name="Route5" color="4" fill="4" visible="yes" active="no"/>
-<layer number="6" name="Route6" color="1" fill="8" visible="yes" active="no"/>
-<layer number="7" name="Route7" color="4" fill="8" visible="yes" active="no"/>
-<layer number="8" name="Route8" color="1" fill="2" visible="yes" active="no"/>
-<layer number="9" name="Route9" color="4" fill="2" visible="yes" active="no"/>
-<layer number="10" name="Route10" color="1" fill="7" visible="yes" active="no"/>
-<layer number="11" name="Route11" color="4" fill="7" visible="yes" active="no"/>
-<layer number="12" name="Route12" color="1" fill="5" visible="yes" active="no"/>
-<layer number="13" name="Route13" color="4" fill="5" visible="yes" active="no"/>
-<layer number="14" name="Route14" color="1" fill="6" visible="yes" active="no"/>
-<layer number="15" name="Route15" color="11" fill="1" visible="yes" active="no"/>
-<layer number="16" name="Bottom" color="1" fill="1" visible="yes" active="no"/>
-<layer number="17" name="Pads" color="2" fill="1" visible="yes" active="no"/>
-<layer number="18" name="Vias" color="2" fill="1" visible="yes" active="no"/>
-<layer number="19" name="Unrouted" color="6" fill="1" visible="yes" active="no"/>
-<layer number="20" name="Dimension" color="15" fill="1" visible="yes" active="no"/>
-<layer number="21" name="tPlace" color="7" fill="1" visible="yes" active="no"/>
-<layer number="22" name="bPlace" color="14" fill="1" visible="yes" active="no"/>
-<layer number="23" name="tOrigins" color="15" fill="1" visible="yes" active="no"/>
-<layer number="24" name="bOrigins" color="15" fill="1" visible="yes" active="no"/>
-<layer number="25" name="tNames" color="7" fill="1" visible="yes" active="no"/>
-<layer number="26" name="bNames" color="14" fill="1" visible="yes" active="no"/>
-<layer number="27" name="tValues" color="7" fill="1" visible="yes" active="no"/>
-<layer number="28" name="bValues" color="7" fill="1" visible="yes" active="no"/>
+<layer number="1" name="Top" color="4" fill="1" visible="no" active="no"/>
+<layer number="2" name="Route2" color="13" fill="1" visible="no" active="no"/>
+<layer number="3" name="Route3" color="4" fill="3" visible="no" active="no"/>
+<layer number="4" name="Route4" color="1" fill="4" visible="no" active="no"/>
+<layer number="5" name="Route5" color="4" fill="4" visible="no" active="no"/>
+<layer number="6" name="Route6" color="1" fill="8" visible="no" active="no"/>
+<layer number="7" name="Route7" color="4" fill="8" visible="no" active="no"/>
+<layer number="8" name="Route8" color="1" fill="2" visible="no" active="no"/>
+<layer number="9" name="Route9" color="4" fill="2" visible="no" active="no"/>
+<layer number="10" name="Route10" color="1" fill="7" visible="no" active="no"/>
+<layer number="11" name="Route11" color="4" fill="7" visible="no" active="no"/>
+<layer number="12" name="Route12" color="1" fill="5" visible="no" active="no"/>
+<layer number="13" name="Route13" color="4" fill="5" visible="no" active="no"/>
+<layer number="14" name="Route14" color="1" fill="6" visible="no" active="no"/>
+<layer number="15" name="Route15" color="11" fill="1" visible="no" active="no"/>
+<layer number="16" name="Bottom" color="1" fill="1" visible="no" active="no"/>
+<layer number="17" name="Pads" color="2" fill="1" visible="no" active="no"/>
+<layer number="18" name="Vias" color="2" fill="1" visible="no" active="no"/>
+<layer number="19" name="Unrouted" color="6" fill="1" visible="no" active="no"/>
+<layer number="20" name="Dimension" color="15" fill="1" visible="no" active="no"/>
+<layer number="21" name="tPlace" color="7" fill="1" visible="no" active="no"/>
+<layer number="22" name="bPlace" color="14" fill="1" visible="no" active="no"/>
+<layer number="23" name="tOrigins" color="15" fill="1" visible="no" active="no"/>
+<layer number="24" name="bOrigins" color="15" fill="1" visible="no" active="no"/>
+<layer number="25" name="tNames" color="7" fill="1" visible="no" active="no"/>
+<layer number="26" name="bNames" color="14" fill="1" visible="no" active="no"/>
+<layer number="27" name="tValues" color="7" fill="1" visible="no" active="no"/>
+<layer number="28" name="bValues" color="7" fill="1" visible="no" active="no"/>
 <layer number="29" name="tStop" color="7" fill="3" visible="no" active="no"/>
 <layer number="30" name="bStop" color="7" fill="6" visible="no" active="no"/>
@@
 <layer number="35" name="tGlue" color="7" fill="4" visible="no" active="no"/>
 <layer number="36" name="bGlue" color="7" fill="5" visible="no" active="no"/>
-<layer number="37" name="tTest" color="7" fill="1" visible="yes" active="no"/>
-<layer number="38" name="bTest" color="7" fill="1" visible="yes" active="no"/>
+<layer number="37" name="tTest" color="7" fill="1" visible="no" active="no"/>
+<layer number="38" name="bTest" color="7" fill="1" visible="no" active="no"/>
 <layer number="39" name="tKeepout" color="4" fill="11" visible="no" active="no"/>
 <layer number="40" name="bKeepout" color="1" fill="11" visible="no" active="no"/>
@@
 <layer number="44" name="Drills" color="7" fill="1" visible="no" active="no"/>
 <layer number="45" name="Holes" color="7" fill="1" visible="no" active="no"/>
-<layer number="46" name="Milling" color="3" fill="1" visible="yes" active="no"/>
-<layer number="47" name="Measures" color="7" fill="1" visible="yes" active="no"/>
-<layer number="48" name="Document" color="7" fill="1" visible="yes" active="no"/>
-<layer number="49" name="Reference" color="7" fill="1" visible="yes" active="no"/>
-<layer number="50" name="dxf" color="7" fill="1" visible="yes" active="no"/>
-<layer number="51" name="tDocu" color="7" fill="1" visible="yes" active="no"/>
-<layer number="52" name="bDocu" color="14" fill="1" visible="yes" active="no"/>
-<layer number="53" name="tGND_GNDA" color="7" fill="9" visible="yes" active="no"/>
-<layer number="54" name="bGND_GNDA" color="1" fill="9" visible="yes" active="no"/>
-<layer number="56" name="wert" color="7" fill="1" visible="yes" active="no"/>
-<layer number="57" name="tCAD" color="7" fill="1" visible="yes" active="no"/>
-<layer number="59" name="tCarbon" color="7" fill="1" visible="yes" active="no"/>
-<layer number="60" name="bCarbon" color="7" fill="1" visible="yes" active="no"/>
+<layer number="46" name="Milling" color="3" fill="1" visible="no" active="no"/>
+<layer number="47" name="Measures" color="7" fill="1" visible="no" active="no"/>
+<layer number="48" name="Document" color="7" fill="1" visible="no" active="no"/>
+<layer number="49" name="Reference" color="7" fill="1" visible="no" active="no"/>
+<layer number="50" name="dxf" color="7" fill="1" visible="no" active="no"/>
+<layer number="51" name="tDocu" color="7" fill="1" visible="no" active="no"/>
+<layer number="52" name="bDocu" color="14" fill="1" visible="no" active="no"/>
+<layer number="53" name="tGND_GNDA" color="7" fill="9" visible="no" active="no"/>
+<layer number="54" name="bGND_GNDA" color="1" fill="9" visible="no" active="no"/>
+<layer number="56" name="wert" color="7" fill="1" visible="no" active="no"/>
+<layer number="57" name="tCAD" color="7" fill="1" visible="no" active="no"/>
+<layer number="59" name="tCarbon" color="7" fill="1" visible="no" active="no"/>
+<layer number="60" name="bCarbon" color="7" fill="1" visible="no" active="no"/>
 <layer number="90" name="Modules" color="5" fill="1" visible="yes" active="yes"/>
 <layer number="91" name="Nets" color="2" fill="1" visible="yes" active="yes"/>
@@
 <instance part="JP3" gate="A" x="-71.12" y="96.52"/>
 <instance part="LED1" gate="G$1" x="-99.06" y="78.74"/>
-<instance part="LED2" gate="G$1" x="-86.36" y="66.04" rot="R180"/>
+<instance part="LED2" gate="G$1" x="-86.36" y="68.58"/>
 <instance part="R65" gate="G$1" x="-99.06" y="66.04" rot="R90"/>
 <instance part="SUPPLY1" gate="GND" x="-99.06" y="58.42"/>
@@
 </segment>
 <segment>
-<pinref part="LED2" gate="G$1" pin="A"/>
+<pinref part="LED2" gate="G$1" pin="C"/>
 <wire x1="-86.36" y1="63.5" x2="-86.36" y2="58.42" width="0.1524" layer="91"/>
-<label x="-83.82" y="58.42" size="1.778" layer="95"/>
+<label x="-86.36" y="58.42" size="1.778" layer="95"/>
 </segment>
 </net>
@@
 </segment>
 </net>
-<net name="N$11" class="0">
+<net name="N$1" class="0">
 <segment>
 <pinref part="R66" gate="G$1" pin="1"/>
-<pinref part="LED2" gate="G$1" pin="C"/>
+<pinref part="LED2" gate="G$1" pin="A"/>
 <wire x1="-86.36" y1="73.66" x2="-86.36" y2="71.12" width="0.1524" layer="91"/>
 </segment>
