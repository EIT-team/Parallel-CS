File: schematics/Connector.Filter.Board/Connector.Board.sch (EAGLE design)
At the start: 212 parts, among them U1 AD8244, U10 AD8244, U11 AD8244, U12 AD8244, U13 AD8244, U14 AD8244, U15 AD8244, U16 AD8244, U17 AD8244, U18 AD8244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

Commit message: Finished PWR GND
Parts:
- added J1, J2: (no value), SparkFun-Connectors:JST_2MM_MALE
- added JP3, JP4: (no value), pinhead:PINHD-2X2
- added LED1, LED2: (no value), led:LEDSML0805
- added R65, R66: (no value), resistor:R-EU_R0402
- C81, C82: value (none) -> 2.2uF
- C83, C84: value (none) -> 0.1uF; device resistor:C-EUC0805 -> resistor:C-EUC0402
- C85, C86: value (none) -> 10nF; device resistor:C-EUC0805 -> resistor:C-EUC0402
- JP1, JP2: device pinhead:PINHD-1X2/90 -> pinhead:PINHD-1X2
Connections:
- new net B1+: J1.+, JP1.1, JP3.1
- new net B1-: J1.-, JP1.2, JP3.3
- new net B2+: J2.+, JP2.1, JP4.1
- new net B2-: J2.-, JP2.2, JP4.3
- new net N$11: LED2.C, R66.1
- new net N$9: LED1.C, R65.2
- net GND: now also JP3.4, JP4.2, R65.1, R66.2; no longer JP1.2, JP2.2
- net V+: now also JP3.2, LED1.A; no longer JP1.1
- net V-: now also JP4.4, LED2.A; no longer JP2.1
Other:
- moved on the sheet: JP1, JP2
Changed lines of the file:
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@@
 <layers>
 <layer number="1" name="Top" color="4" fill="1" visible="yes" active="no"/>
-<layer number="2" name="Route2" color="13" fill="3" visible="yes" active="no"/>
+<layer number="2" name="Route2" color="13" fill="1" visible="yes" active="no"/>
 <layer number="3" name="Route3" color="4" fill="3" visible="yes" active="no"/>
 <layer number="4" name="Route4" color="1" fill="4" visible="yes" active="no"/>
@@
 <part name="TP31" library="connector_board_lib" deviceset="TOUCHPROOF" device=""/>
 <part name="TP32" library="connector_board_lib" deviceset="TOUCHPROOF" device=""/>
-<part name="JP1" library="pinhead" deviceset="PINHD-1X2" device="/90"/>
-<part name="JP2" library="pinhead" deviceset="PINHD-1X2" device="/90"/>
+<part name="JP1" library="pinhead" deviceset="PINHD-1X2" device=""/>
+<part name="JP2" library="pinhead" deviceset="PINHD-1X2" device=""/>
 <part name="SUPPLY2" library="supply2" deviceset="GND" device=""/>
 <part name="SUPPLY1" library="supply2" deviceset="GND" device=""/>
-<part name="C83" library="resistor" deviceset="C-EU" device="C0805"/>
-<part name="C84" library="resistor" deviceset="C-EU" device="C0805"/>
+<part name="C83" library="resistor" deviceset="C-EU" device="C0402" value="0.1uF"/>
+<part name="C84" library="resistor" deviceset="C-EU" device="C0402" value="0.1uF"/>
 <part name="SUPPLY3" library="supply2" deviceset="GND" device=""/>
 <part name="SUPPLY4" library="supply2" deviceset="GND" device=""/>
@@
 <part name="SUPPLY5" library="supply2" deviceset="GND" device=""/>
 <part name="SUPPLY6" library="supply2" deviceset="GND" device=""/>
-<part name="C85" library="resistor" deviceset="C-EU" device="C0805"/>
-<part name="C81" library="resistor" deviceset="C-EU" device="C0805"/>
-<part name="C82" library="resistor" deviceset="C-EU" device="C0805"/>
-<part name="C86" library="resistor" deviceset="C-EU" device="C0805"/>
+<part name="C85" library="resistor" deviceset="C-EU" device="C0402" value="10nF"/>
+<part name="C81" library="resistor" deviceset="C-EU" device="C0805" value="2.2uF"/>
+<part name="C82" library="resistor" deviceset="C-EU" device="C0805" value="2.2uF"/>
+<part name="C86" library="resistor" deviceset="C-EU" device="C0402" value="10nF"/>
 <part name="C27" library="resistor" deviceset="C-EU" device="C0805"/>
 <part name="R41" library="resistor" deviceset="R-EU_" device="R0805"/>
@@
 <part name="R24" library="resistor" deviceset="R-EU_" device="R0402"/>
 <part name="GND24" library="supply1" deviceset="GND" device=""/>
+<part name="J1" library="SparkFun-Connectors" deviceset="JST_2MM_MALE" device=""/>
+<part name="J2" library="SparkFun-Connectors" deviceset="JST_2MM_MALE" device=""/>
+<part name="JP3" library="pinhead" deviceset="PINHD-2X2" device=""/>
+<part name="JP4" library="pinhead" deviceset="PINHD-2X2" device=""/>
+<part name="LED1" library="led" deviceset="LED" device="SML0805"/>
+<part name="LED2" library="led" deviceset="LED" device="SML0805"/>
+<part name="R65" library="resistor" deviceset="R-EU_" device="R0402"/>
+<part name="SUPPLY7" library="supply2" deviceset="GND" device=""/>
+<part name="R66" library="resistor" deviceset="R-EU_" device="R0402"/>
+<part name="SUPPLY8" library="supply2" deviceset="GND" device=""/>
 </parts>
 <sheets>
@@
 </plain>
 <instances>
-<instance part="JP1" gate="G$1" x="-60.96" y="109.22"/>
-<instance part="JP2" gate="G$1" x="-60.96" y="91.44"/>
-<instance part="SUPPLY2" gate="GND" x="-78.74" y="88.9"/>
-<instance part="SUPPLY1" gate="GND" x="-78.74" y="104.14"/>
+<instance part="JP1" gate="G$1" x="-101.6" y="109.22"/>
+<instance part="JP2" gate="G$1" x="-101.6" y="96.52"/>
+<instance part="SUPPLY2" gate="GND" x="-76.2" y="101.6" rot="R180"/>
+<instance part="SUPPLY1" gate="GND" x="-60.96" y="104.14"/>
 <instance part="C83" gate="G$1" x="-30.48" y="116.84"/>
 <instance part="C84" gate="G$1" x="-30.48" y="88.9"/>
@@
 <instance part="C82" gate="G$1" x="-38.1" y="88.9"/>
 <instance part="C86" gate="G$1" x="-22.86" y="88.9"/>
+<instance part="J1" gate="G$1" x="-121.92" y="109.22" rot="R90"/>
+<instance part="J2" gate="G$1" x="-121.92" y="96.52" rot="R90"/>
+<instance part="JP3" gate="A" x="-71.12" y="109.22"/>
+<instance part="JP4" gate="A" x="-86.36" y="96.52"/>
+<instance part="LED1" gate="G$1" x="-99.06" y="78.74"/>
+<instance part="LED2" gate="G$1" x="-86.36" y="66.04" rot="R180"/>
+<instance part="R65" gate="G$1" x="-99.06" y="66.04" rot="R90"/>
+<instance part="SUPPLY7" gate="GND" x="-99.06" y="58.42"/>
+<instance part="R66" gate="G$1" x="-86.36" y="78.74" rot="R90"/>
+<instance part="SUPPLY8" gate="GND" x="-86.36" y="86.36" rot="R180"/>
 </instances>
 <busses>
@@
 <net name="V-" class="0">
 <segment>
-<pinref part="JP2" gate="G$1" pin="1"/>
-<wire x1="-63.5" y1="93.98" x2="-78.74" y2="93.98" width="0.1524" layer="91"/>
-<wire x1="-78.74" y1="93.98" x2="-78.74" y2="96.52" width="0.1524" layer="91"/>
-<label x="-78.74" y="96.52" size="1.778" layer="95"/>
+<wire x1="-76.2" y1="96.52" x2="-76.2" y2="93.98" width="0.1524" layer="91"/>
+<label x="-76.2" y="93.98" size="1.778" layer="95"/>
+<pinref part="JP4" gate="A" pin="4"/>
+<wire x1="-83.82" y1="96.52" x2="-76.2" y2="96.52" width="0.1524" layer="91"/>
 </segment>
 <segment>
@@
 <wire x1="27.94" y1="119.38" x2="27.94" y2="114.3" width="0.1524" layer="91"/>
 </segment>
+<segment>
+<pinref part="LED2" gate="G$1" pin="A"/>
+<wire x1="-86.36" y1="63.5" x2="-86.36" y2="58.42" width="0.1524" layer="91"/>
+<label x="-83.82" y="58.42" size="1.778" layer="95"/>
+</segment>
 </net>
 <net name="V+" class="0">
 <segment>
-<pinref part="JP1" gate="G$1" pin="1"/>
-<wire x1="-63.5" y1="111.76" x2="-78.74" y2="111.76" width="0.1524" layer="91"/>
-<wire x1="-78.74" y1="111.76" x2="-78.74" y2="114.3" width="0.1524" layer="91"/>
-<label x="-78.74" y="114.3" size="1.778" layer="95"/>
+<wire x1="-60.96" y1="111.76" x2="-60.96" y2="114.3" width="0.1524" layer="91"/>
+<label x="-60.96" y="114.3" size="1.778" layer="95"/>
+<pinref part="JP3" gate="A" pin="2"/>
+<wire x1="-68.58" y1="111.76" x2="-60.96" y2="111.76" width="0.1524" layer="91"/>
 </segment>
 <segment>
@@
 <wire x1="17.78" y1="119.38" x2="17.78" y2="114.3" width="0.1524" layer="91"/>
 </segment>
-</net>
-<net name="GND" class="0">
-<segment>
-<pinref part="JP2" gate="G$1" pin="2"/>
-<wire x1="-63.5" y1="91.44" x2="-78.74" y2="91.44" width="0.1524" layer="91"/>
-<pinref part="SUPPLY2" gate="GND" pin="GND"/>
-</segment>
 <segment>
-<pinref part="JP1" gate="G$1" pin="2"/>
-<wire x1="-63.5" y1="109.22" x2="-78.74" y2="109.22" width="0.1524" layer="91"/>
-<wire x1="-78.74" y1="109.22" x2="-78.74" y2="106.68" width="0.1524" layer="91"/>
-<pinref part="SUPPLY1" gate="GND" pin="GND"/>
+<pinref part="LED1" gate="G$1" pin="A"/>
+<wire x1="-99.06" y1="81.28" x2="-99.06" y2="83.82" width="0.1524" layer="91"/>
+<label x="-99.06" y="83.82" size="1.778" layer="95"/>
 </segment>
+</net>
+<net name="GND" class="0">
 <segment>
 <pinref part="C84" gate="G$1" pin="2"/>
@@
 <pinref part="SUPPLY6" gate="GND" pin="GND"/>
 </segment>
+<segment>
+<wire x1="-66.04" y1="109.22" x2="-60.96" y2="109.22" width="0.1524" layer="91"/>
+<pinref part="SUPPLY1" gate="GND" pin="GND"/>
+<wire x1="-60.96" y1="109.22" x2="-60.96" y2="106.68" width="0.1524" layer="91"/>
+<pinref part="JP3" gate="A" pin="4"/>
+<wire x1="-66.04" y1="109.22" x2="-68.58" y2="109.22" width="0.1524" layer="91"/>
+</segment>
+<segment>
+<pinref part="JP4" gate="A" pin="2"/>
+<pinref part="SUPPLY2" gate="GND" pin="GND"/>
+<wire x1="-83.82" y1="99.06" x2="-76.2" y2="99.06" width="0.1524" layer="91"/>
+</segment>
+<segment>
+<pinref part="R65" gate="G$1" pin="1"/>
+<pinref part="SUPPLY7" gate="GND" pin="GND"/>
+</segment>
+<segment>
+<pinref part="R66" gate="G$1" pin="2"/>
+<pinref part="SUPPLY8" gate="GND" pin="GND"/>
+</segment>
+</net>
+<net name="B1+" class="0">
+<segment>
+<pinref part="J1" gate="G$1" pin="+"/>
+<pinref part="JP1" gate="G$1" pin="1"/>
+<wire x1="-116.84" y1="111.76" x2="-104.14" y2="111.76" width="0.1524" layer="91"/>
+<label x="-116.84" y="111.76" size="1.778" layer="95"/>
+<pinref part="JP3" gate="A" pin="1"/>
+<wire x1="-104.14" y1="111.76" x2="-76.2" y2="111.76" width="0.1524" layer="91"/>
+<junction x="-104.14" y="111.76"/>
+</segment>
+</net>
+<net name="B1-" class="0">
+<segment>
+<pinref part="J1" gate="G$1" pin="-"/>
+<pinref part="JP1" gate="G$1" pin="2"/>
+<wire x1="-116.84" y1="109.22" x2="-104.14" y2="109.22" width="0.1524" layer="91"/>
+<label x="-116.84" y="109.22" size="1.778" layer="95"/>
+<pinref part="JP3" gate="A" pin="3"/>
+<wire x1="-104.14" y1="109.22" x2="-76.2" y2="109.22" width="0.1524" layer="91"/>
+<junction x="-104.14" y="109.22"/>
+</segment>
+</net>
+<net name="B2+" class="0">
+<segment>
+<pinref part="J2" gate="G$1" pin="+"/>
+<pinref part="JP2" gate="G$1" pin="1"/>
+<wire x1="-116.84" y1="99.06" x2="-104.14" y2="99.06" width="0.1524" layer="91"/>
+<label x="-116.84" y="99.06" size="1.778" layer="95"/>
+<pinref part="JP4" gate="A" pin="1"/>
+<wire x1="-104.14" y1="99.06" x2="-91.44" y2="99.06" width="0.1524" layer="91"/>
+<junction x="-104.14" y="99.06"/>
+</segment>
+</net>
+<net name="B2-" class="0">
+<segment>
+<pinref part="J2" gate="G$1" pin="-"/>
+<pinref part="JP2" gate="G$1" pin="2"/>
+<wire x1="-116.84" y1="96.52" x2="-104.14" y2="96.52" width="0.1524" layer="91"/>
+<label x="-116.84" y="96.52" size="1.778" layer="95"/>
+<pinref part="JP4" gate="A" pin="3"/>
+<wire x1="-104.14" y1="96.52" x2="-91.44" y2="96.52" width="0.1524" layer="91"/>
+<junction x="-104.14" y="96.52"/>
+</segment>
+</net>
+<net name="N$9" class="0">
+<segment>
+<pinref part="LED1" gate="G$1" pin="C"/>
+<pinref part="R65" gate="G$1" pin="2"/>
+<wire x1="-99.06" y1="73.66" x2="-99.06" y2="71.12" width="0.1524" layer="91"/>
+</segment>
+</net>
+<net name="N$11" class="0">
+<segment>
+<pinref part="R66" gate="G$1" pin="1"/>
+<pinref part="LED2" gate="G$1" pin="C"/>
+<wire x1="-86.36" y1="73.66" x2="-86.36" y2="71.12" width="0.1524" layer="91"/>
+</segment>
 </net>

Commit message: Finished Routing and First BOM
Parts:
- C19, C20, C22, C23, C24, C25, C26, C27, C28, C29, C30, C49, C50, C52, C53, C54, C55, C56, C57, C58, C59, C60, C73, C74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: value (none) -> 1uf
- C21, C51, C75: value 0.1uF -> 1uf
- R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R2, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R3, R30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: value (none) -> 1M
- R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56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: value (none) -> 1.6M
- R65, R66: value (none) -> 1k
Connections:
- net B1+: now also JP4.1; no longer JP3.1
- net B1-: now also JP4.3; no longer JP3.3
- net B2+: now also JP3.1; no longer JP4.1
- net B2-: now also JP3.3; no longer JP4.3
- net GND: now also JP3.2, JP4.4; no longer JP3.4, JP4.2
- net V+: now also JP4.2; no longer JP3.2
- net V-: now also JP3.4; no longer JP4.4
Other:
- moved on the sheet: JP3, JP4
