# Repository EIT-team/Parallel-CS (continued)

## EAGLE design schematics/V4.Power.Board.Dec.2016/power_supply_board.brd

Parts:
FEMALE: F37HPS; F37HP
JP_NEG_IN: M02-JST-2MM-SMT; JST-2-SMD
JP_NEG_OUT: M02-JST-2MM-SMT; JST-2-SMD
JP_POS_IN: M02-JST-2MM-SMT; JST-2-SMD
JP_POS_OUT: M02-JST-2MM-SMT; JST-2-SMD
LED1, LED2: LED_ELED0402; C0402
MALE1, MALE2: M37HPS; M37HP
R1, R2: R-US_R0805; R0805
S1, S2: PVA1; PVA1F

Connections:
unnamed: LED1.A, R2.2
unnamed: LED2.A, R1.2
unnamed: JP_POS_IN.2, S1.2
unnamed: JP_POS_IN.1, S1.4
unnamed: JP_NEG_IN.2, S2.2
unnamed: JP_NEG_IN.1, S2.4
unnamed: JP_POS_OUT.2, R2.1, S1.1 (S)
unnamed: JP_POS_OUT.1, LED1.C, S1.3 (S)
unnamed: JP_NEG_OUT.2, R1.1, S2.1 (S)
unnamed: JP_NEG_OUT.1, LED2.C, S2.3 (S)
unnamed: FEMALE.1, MALE1.1 (M), MALE2.1 (M)
unnamed: FEMALE.2, MALE1.2 (M), MALE2.2 (M)
unnamed: FEMALE.3, MALE1.3 (M), MALE2.3 (M)
unnamed: FEMALE.4, MALE1.4 (M), MALE2.4 (M)
unnamed: FEMALE.5, MALE1.5 (M), MALE2.5 (M)
unnamed: FEMALE.6, MALE1.6 (M), MALE2.6 (M)
unnamed: FEMALE.7, MALE1.7 (M), MALE2.7 (M)
unnamed: FEMALE.8, MALE1.8 (M), MALE2.8 (M)
unnamed: FEMALE.9, MALE1.9 (M), MALE2.9 (M)
unnamed: FEMALE.10, MALE1.10 (M), MALE2.10 (M)
unnamed: FEMALE.11, MALE1.11 (M), MALE2.11 (M)
unnamed: FEMALE.12, MALE1.12 (M), MALE2.12 (M)
unnamed: FEMALE.13, MALE1.13 (M), MALE2.13 (M)
unnamed: FEMALE.14, MALE1.14 (M), MALE2.14 (M)
unnamed: FEMALE.15, MALE1.15 (M), MALE2.15 (M)
unnamed: FEMALE.16, MALE1.16 (M), MALE2.16 (M)
unnamed: FEMALE.17, MALE1.17 (M), MALE2.17 (M)
unnamed: FEMALE.18, MALE1.18 (M), MALE2.18 (M)
unnamed: FEMALE.19, MALE1.19 (M), MALE2.19 (M)
unnamed: FEMALE.20, MALE1.20 (M), MALE2.20 (M)
unnamed: FEMALE.21, MALE1.21 (M), MALE2.21 (M)
unnamed: FEMALE.22, MALE1.22 (M), MALE2.22 (M)
unnamed: FEMALE.23, MALE1.23 (M), MALE2.23 (M)
unnamed: FEMALE.24, MALE1.24 (M), MALE2.24 (M)
unnamed: FEMALE.25, MALE1.25 (M), MALE2.25 (M)
unnamed: FEMALE.26, MALE1.26 (M), MALE2.26 (M)
unnamed: FEMALE.27, MALE1.27 (M), MALE2.27 (M)
unnamed: FEMALE.28, MALE1.28 (M), MALE2.28 (M)
unnamed: FEMALE.29, MALE1.29 (M), MALE2.29 (M)
unnamed: FEMALE.30, MALE1.30 (M), MALE2.30 (M)
unnamed: FEMALE.31, MALE1.31 (M), MALE2.31 (M)
unnamed: FEMALE.32, MALE1.32 (M), MALE2.32 (M)
unnamed: FEMALE.33, MALE1.33 (M), MALE2.33 (M)
unnamed: FEMALE.34, MALE1.34 (M), MALE2.34 (M)
unnamed: FEMALE.35, MALE1.35 (M), MALE2.35 (M)
unnamed: FEMALE.36, MALE1.36 (M), MALE2.36 (M)
unnamed: FEMALE.37, MALE1.37 (M), MALE2.37 (M)

Board: 2 copper layers, 100.0 x 100.0 mm, 13 parts (0 on the bottom side), 47 nets.

## EAGLE design schematics/Full Board Prototype/Parallel CS Prototype multiple sources.brd

Parts:
JP33: PWR; 1X02
JP34: PINHD-1X2; 1X02
U1: ADG714BRUZ; SOP65P640X120-24N
X2: CTR_ARD; F09HP

Connections:
ARD_5V: U1.2 (VDD), X2.4; also elsewhere on the board
FSYNC_ARD: U1.5 (S1), U1.7 (S2), U1.9 (S3), U1.11 (S4), U1.14 (S5), U1.16 (S6), U1.18 (S7), U1.20 (S8), X2.9
FSYNC_IN: U1.6 (D1); also elsewhere on the board
GND: JP33.1, JP34.2, U1.4 (GND), U1.21 (VSS), X2.6; also elsewhere on the board
SCLK_IN: X2.2; also elsewhere on the board
SDATA_IN: X2.3; also elsewhere on the board
SW_DIN: U1.3 (DIN), X2.5
SW_SCLK: U1.1 (SCLK), X2.1
SW_~RESET: U1.23 (~RESET), X2.8
SW_~SYNC: U1.24 (~SYNC), X2.7
VDD: JP33.2, JP34.1; also elsewhere on the board

Notes on the sheet:
Switch to route FSYNC, powered by Arduino
DSUB FROM ARDUINO
Battery Connector

Parts:
C_BIAS: 4.7u; C0805
C_BYP: 10n; C0402
C_IN: 2.2u; C0805
C_ISO1A, C_ISO2A: 1u; C0402
C_ISO1B, C_ISO2B: 0.1u; C0402
C_OUT1: 47u; C0805
C_OUT2: 10u; C0805
DIGITAL_ISO1: ADUM1410ARWZ; SOIC127P1032X265-16N
LED1: LED_ESML0603; LED_SML0603
R_ADJ1: 6.8k; R0201
R_ADJ2: 300k; R0201
R_LED: 2700; R0402
S1: TL36POPVB4; PVB4-EE
U$1: LTM8048; BGA-49

Connections:
ARD_5V: C_ISO1A.1, C_ISO1B.1, DIGITAL_ISO1.1 (VDD1); also elsewhere on the board
FSYNC: DIGITAL_ISO1.14 (VOA); also elsewhere on the board
FSYNC_IN: DIGITAL_ISO1.3 (VIA); also elsewhere on the board
GND: C_BIAS.2, C_IN.2, C_ISO1A.2, C_ISO1B.2, DIGITAL_ISO1.2 (GND1_2), DIGITAL_ISO1.7 (DISABLE), DIGITAL_ISO1.8 (GND1), R_ADJ1.1, S1.1 (O), U$1.GND@1 (GND), U$1.GND@2 (GND), U$1.GND@3 (GND), U$1.GND@4 (GND), U$1.GND@5 (GND), U$1.GND@6 (GND), U$1.GND@7 (GND), U$1.GND@8 (GND), U$1.GND@9 (GND), U$1.GND@10 (GND), U$1.GND@11 (GND), U$1.GND@12 (GND), U$1.GND@13 (GND), U$1.GND@14 (GND), U$1.GND@15 (GND), U$1.GND@16 (GND); also elsewhere on the board
GND_CS: C_ISO2A.2, C_ISO2B.2, C_OUT1.1, C_OUT2.1, DIGITAL_ISO1.9 (GND2_2), DIGITAL_ISO1.15 (GND2), LED1.C, R_ADJ2.2, U$1.VOUT-@1 (VOUT-), U$1.VOUT-@2 (VOUT-), U$1.VOUT-@3 (VOUT-), U$1.VOUT-@4 (VOUT-), U$1.VOUT-@5 (VOUT-), U$1.VOUT-@6 (VOUT-), U$1.VOUT-@7 (VOUT-), U$1.VOUT-@8 (VOUT-), U$1.VOUT-@9 (VOUT-); also elsewhere on the board
unnamed: C_BYP.1, U$1.BYP
unnamed: S1.2@1, S1.2@2, U$1.RUN
unnamed: LED1.A, R_LED.1
unnamed: C_BIAS.1, U$1.BIAS
unnamed: R_ADJ1.2, U$1.ADJ1
unnamed: R_ADJ2.1, U$1.ADJ2
SCLK: DIGITAL_ISO1.12 (VOC); also elsewhere on the board
SCLK_IN: DIGITAL_ISO1.5 (VIC); also elsewhere on the board
SDATA: DIGITAL_ISO1.13 (VOB); also elsewhere on the board
SDATA_IN: DIGITAL_ISO1.4 (VIB); also elsewhere on the board
VDD: C_IN.1, S1.3 (S), U$1.VIN@1 (VIN), U$1.VIN@2 (VIN), U$1.VIN@3 (VIN), U$1.VIN@4 (VIN); also elsewhere on the board
VDD_CS_ANA: C_BYP.2, C_OUT2.2, U$1.VOUT2@1 (VOUT2), U$1.VOUT2@2 (VOUT2), U$1.VOUT2@3 (VOUT2), U$1.VOUT2@4 (VOUT2); also elsewhere on the board
VDD_CS_DIG: C_ISO2A.1, C_ISO2B.1, C_OUT1.2, DIGITAL_ISO1.16 (VDD2), R_LED.2, U$1.VOUT1@1 (VOUT1), U$1.VOUT1@2 (VOUT1), U$1.VOUT1@3 (VOUT1), U$1.VOUT1@4 (VOUT1), U$1.VOUT1@5 (VOUT1), U$1.VOUT1@6 (VOUT1); also elsewhere on the board

Notes on the sheet:
Isolated Linear Regulator
Digital Isolator for SPI signals VDD1 powered from Arduino VDD2 powered from regulator output Vout1
Decoupling Caps for VDD2 & VDD1
Vout1 ~5V, Vout2 ~3.3V
Pushbutton switch to connect RUN pin to VDD/GND
On/Off Status LED

Parts:
CLOCK: LTC69000; SOT95P280X100-6N
C_CLK_BYP: 0.1u; C0402
C_DDS3: 10n; C0402
C_DDS4: 100n; C0402
C_DDS_BYP1, C_DDS_BYP4: 0.1u; C0402
C_DDS_BYP2, C_DDS_BYP3: 10u; C0402
DDS: AD9833BRMZ; SOP50P490X110-10N
H_H4: 10k; R0603
I_OUT: 332-02
OPAMP: LMC6482IMM; SOP65P490X109-8N
R_H1A, R_H2A, R_H3: 10k; R0603
R_H1B, R_H2B: 3.3k; R0603
R_SET: 20k; R0603
S2: TL46WOMULTICOMP_2MD; TL4XPO
TP_GND: PTR1PAD1-13; P1-13
TP_VSIN: PTR1PAD1-13; P1-13

Connections:
CLK_OUT: CLOCK.1 (OUT), DDS.5 (MCLK)
COMP: C_DDS3.2, DDS.1 (COMP)
FSYNC: DDS.8 (FSYNC); also elsewhere on the board
GND_CS: CLOCK.2 (GND), CLOCK.3 (DIV), C_CLK_BYP.2, C_DDS4.1, C_DDS_BYP1.2, C_DDS_BYP2.2, C_DDS_BYP3.2, C_DDS_BYP4.2, DDS.4 (DGND), DDS.9 (AGND), I_OUT.2, OPAMP.4 (V-), R_H3.1, R_SET.1, TP_GND.TP; also elsewhere on the board
IOUT: I_OUT.1, OPAMP.3 (POSA), S2.2
unnamed: C_DDS4.2, DDS.3 (CAP/2.5V)
unnamed: R_H2A.2, S2.6 (S1)
unnamed: CLOCK.4 (SET), R_SET.2
unnamed: R_H2B.2, S2.4 (O1)
unnamed: R_H1B.2, R_H2B.1, S2.1 (O)
unnamed: R_H1A.2, R_H2A.1, S2.3 (S)
NEGA: H_H4.1, OPAMP.2 (NEGA), R_H3.2
OP_OUTA: H_H4.2, OPAMP.1 (OUTA), S2.5 (P1)
SCLK: DDS.7 (SCLK); also elsewhere on the board
SDATA: DDS.6 (SDATA); also elsewhere on the board
VDD_CS_ANA: C_DDS_BYP3.1, C_DDS_BYP4.1, OPAMP.8 (V+); also elsewhere on the board
VDD_CS_DIG: CLOCK.6 (V+), C_CLK_BYP.1, C_DDS3.1, C_DDS_BYP1.1, C_DDS_BYP2.1, DDS.2 (VDD); also elsewhere on the board
V_SINE: DDS.10 (VOUT), R_H1A.1, R_H1B.1, TP_VSIN.TP

Notes on the sheet:
Clock output Freq = 10MHz * 20k/R_set
DDS Chip, programmed by SPI
Howland Current Pump Can select between two outputs with different magnitudes
Howland resistor network. DPDT switch selects between 60uA and 200uA output

Parts:
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19, JP20, JP21, JP22, JP23, JP24, JP25, JP26, JP27, JP28, JP29, JP30, JP31, JP32: PINHD-1X1; 1X01
X4: DSUB _T; F37HP
X5: DSUB_B; M37HP

Connections:
OUT_1: JP1.1, X4.1, X5.1
OUT_2: JP2.1, X4.2, X5.2
OUT_3: JP3.1, X4.3, X5.3
OUT_4: JP4.1, X4.4, X5.4
OUT_5: JP5.1, X4.5, X5.5
OUT_6: JP6.1, X4.6, X5.6
OUT_7: JP7.1, X4.7, X5.7
OUT_8: JP8.1, X4.8, X5.8
OUT_9: JP9.1, X4.9, X5.9
OUT_10: JP10.1, X4.10, X5.10
OUT_11: JP11.1, X4.11, X5.11
OUT_12: JP12.1, X4.12, X5.12
OUT_13: JP13.1, X4.13, X5.13
OUT_14: JP14.1, X4.14, X5.14
OUT_15: JP15.1, X4.15, X5.15
OUT_16: JP16.1, X4.16, X5.16
OUT_17: JP17.1, X4.17, X5.17
OUT_18: JP18.1, X4.18, X5.18
OUT_19: JP19.1, X4.19, X5.19
OUT_20: JP20.1, X4.20, X5.20
OUT_21: JP21.1, X4.21, X5.21
OUT_22: JP22.1, X4.22, X5.22
OUT_23: JP23.1, X4.23, X5.23
OUT_24: JP24.1, X4.24, X5.24
OUT_25: JP25.1, X4.25, X5.25
OUT_26: JP26.1, X4.26, X5.26
OUT_27: JP27.1, X4.27, X5.27
OUT_28: JP28.1, X4.28, X5.28
OUT_29: JP29.1, X4.29, X5.29
OUT_30: JP30.1, X4.30, X5.30
OUT_31: JP31.1, X4.31, X5.31
OUT_32: JP32.1, X4.32, X5.32
OUT_33: X4.33, X5.33
OUT_34: X4.34, X5.34
OUT_35: X4.35, X5.35
OUT_36: X4.36, X5.36
OUT_37: X4.37, X5.37

Notes on the sheet:
Molex Jumper Sockets

Parts:
CLOCK1: LTC69000; SOT95P280X100-6N
C_BIAS1: 4.7u; C0805
C_BYP1: 10n; C0402
C_CLK_BYP1: 0.1u; C0402
C_DDS1: 100n; C0402
C_DDS2: 10n; C0402
C_DDS_BYP5, C_DDS_BYP7: 10u; C0402
C_DDS_BYP6, C_DDS_BYP8: 0.1u; C0402
C_IN1: 2.2u; C0805
C_ISO1A1, C_ISO2A1: 1u; C0402
C_ISO1B1, C_ISO2B1: 0.1u; C0402
C_OUT3: 47u; C0805
C_OUT4: 10u; C0805
DDS1: AD9833BRMZ; SOP50P490X110-10N
DIGITAL_ISO2: ADUM1410ARWZ; SOIC127P1032X265-16N
H_H1: 10k; R0603
I_OUT1: 332-02
LED2: LED_ESML0603; LED_SML0603
OPAMP1: LMC6482IMM; SOP65P490X109-8N
R_ADJ3: 6.8k; R0201
R_ADJ4: 300k; R0201
R_H1, R_H1A1, R_H2A1: 10k; R0603
R_H1B1, R_H2B1: 3.3k; R0603
R_LED1: 2700; R0402
R_SET1: 20k; R0603
S3: TL36POPVB4; PVB4-EE
S4: TL46WOMULTICOMP_2MD; TL4XPO
TP_GND1: PTR1PAD1-13; P1-13
TP_VSIN1: PTR1PAD1-13; P1-13
U$2: LTM8048; BGA-49

Connections:
ARD_5V1: C_ISO1A1.1, C_ISO1B1.1, DIGITAL_ISO2.1 (VDD1)
CLK_OUT1: CLOCK1.1 (OUT), DDS1.5 (MCLK)
FSYNC1: DDS1.8 (FSYNC), DIGITAL_ISO2.14 (VOA)
FSYNC_IN1: DIGITAL_ISO2.3 (VIA)
GND1: C_BIAS1.2, C_IN1.2, C_ISO1A1.2, C_ISO1B1.2, DIGITAL_ISO2.2 (GND1_2), DIGITAL_ISO2.7 (DISABLE), DIGITAL_ISO2.8 (GND1), R_ADJ3.1, S3.1 (O), U$2.GND@1 (GND), U$2.GND@2 (GND), U$2.GND@3 (GND), U$2.GND@4 (GND), U$2.GND@5 (GND), U$2.GND@6 (GND), U$2.GND@7 (GND), U$2.GND@8 (GND), U$2.GND@9 (GND), U$2.GND@10 (GND), U$2.GND@11 (GND), U$2.GND@12 (GND), U$2.GND@13 (GND), U$2.GND@14 (GND), U$2.GND@15 (GND), U$2.GND@16 (GND)
IOUT1: I_OUT1.1, OPAMP1.3 (POSA), S4.2
unnamed: C_BIAS1.1, U$2.BIAS
unnamed: R_ADJ3.2, U$2.ADJ1
unnamed: R_ADJ4.1, U$2.ADJ2
unnamed: C_BYP1.1, U$2.BYP
unnamed: CLOCK1.4 (SET), R_SET1.2
unnamed: R_H1B1.2, R_H2B1.1, S4.1 (O)
unnamed: S3.2@1, S3.2@2, U$2.RUN
unnamed: LED2.A, R_LED1.1
unnamed: R_H2A1.2, S4.6 (S1)
unnamed: R_H1A1.2, R_H2A1.1, S4.3 (S)
unnamed: R_H2B1.2, S4.4 (O1)
NEGA1: H_H1.1, OPAMP1.2 (NEGA), R_H1.2
OP_OUTA1: H_H1.2, OPAMP1.1 (OUTA), S4.5 (P1)
SCLK1: DDS1.7 (SCLK), DIGITAL_ISO2.12 (VOC)
SCLK_IN1: DIGITAL_ISO2.5 (VIC)
SDATA1: DDS1.6 (SDATA), DIGITAL_ISO2.13 (VOB)
SDATA_IN1: DIGITAL_ISO2.4 (VIB)
VDD1: C_IN1.1, S3.3 (S), U$2.VIN@1 (VIN), U$2.VIN@2 (VIN), U$2.VIN@3 (VIN), U$2.VIN@4 (VIN)
VDD_CS_ANA1: C_BYP1.2, C_DDS_BYP7.1, C_DDS_BYP8.1, C_OUT4.2, OPAMP1.8 (V+), U$2.VOUT2@1 (VOUT2), U$2.VOUT2@2 (VOUT2), U$2.VOUT2@3 (VOUT2), U$2.VOUT2@4 (VOUT2)
V_SINE1: DDS1.10 (VOUT), R_H1A1.1, R_H1B1.1, TP_VSIN1.TP

Notes on the sheet:
Isolated Linear Regulator
Digital Isolator for SPI signals VDD1 powered from Arduino VDD2 powered from regulator output Vout1
Decoupling Caps for VDD2 & VDD1
Vout1 ~5V, Vout2 ~3.3V
Pushbutton switch to connect RUN pin to VDD/GND
On/Off Status LED
Clock output Freq = 10MHz * 20k/R_set
DDS Chip, programmed by SPI
Howland Current Pump Can select between two outputs with different magnitudes
Howland resistor network. DPDT switch selects between 60uA and 200uA output

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
Board: 2 copper layers, 144.8 x 113.5 mm, 112 parts (6 on the bottom side), 99 nets.

## Commit log

2015-09-28 First commit of Tom's Parallel CS Prototype
2015-09-28 Adding Arduino code for programming the DDS ICs.
2015-09-29 Added ident layer to gerbers and finalised Pick and Place data
2015-09-30 New Gerber files to include solder resist layer
2015-10-07 Updated Pick & Place Data and Ident Gerber File for PCB assembly
2015-10-16 Updating Arduino code to program new switch board
2015-10-19 Working code for programming switches, some tidying up of code still required
2015-10-19 Tided up code
2015-11-02 Added code to do frequency sweep
2015-11-03 Added code to turn off unused DDS chips
2015-11-12 Finalised design for 8 channel parallel CS, to be submitted to fabrication house.
2015-11-24 Final Pick & Place Data, Ident Layers, for Assembly
2015-11-24 Merged development of 8 channel CS to master branch
2015-12-07 Arduino PWM code for generating sine waves
2015-12-09 New 7mm x 8mm PCB to fix clock section of 8 channel parallel board.
2015-12-23 Working code for 8 channel injection, verified by Tom 23.12.15
2016-06-09 Combined V2 and V3 hardware
2016-06-10 Changed frequency variable from int to long, to allow for higher values to be used
2016-07-07 Initial V4 design, single CS
2016-07-12 V4 Design submitted for fab
2016-07-18 Allow programming of frequency from Arduino serial monitor
2016-07-18 Individual programming of phase for each channel
2016-07-18 Minor changes to comments in set_phase function
2016-07-19 Initial code for phase delay between two DDS chips, not yet working
2016-07-19 Cleaned up some comments/unsused code
2016-07-19 Fixed resistor values in V4 PCB layout for HCP
2016-07-19 gitignore update
2016-10-26 Few bits of tidying up code
2016-10-26 More informative status message when progrmaming
2016-10-26 Added instructions for programming CS board
2016-12-06 Added function (Program_Then_Turn_Off) to program the sources for a specified amount of time, then turn them all off/reset
2016-12-16 Power supply connector board design
2016-12-20 V5 Parallel Board started
2016-12-20 Changed power connecters, split output stage op amps into 2 separate ICs for medical safety regs
2016-12-20 Changed FSYNC pull up resistor to pull down
2016-12-21 Changes complete - PCB layout ready for tiling
2016-12-21 Tiled board layout
2017-01-23 V5.1 Board - fixing error with footprint of op-amp
2017-03-20 Tidied up comments and moved some variables to DEFINES
2017-03-20 DDS_PCB.ino
2017-03-20 Tidied up brackets and indentation
2017-03-20 More minor layout fixes
2017-03-20 Moved definitions to separate header file and created header file just for frequency definitions
2017-03-20 Fixed typos
2017-03-20 Added CLOSE_ALL_SWITCHES
2017-03-20 Added default case when processing Serial commands from user
2017-03-20 Changed all delay commands to use definitions rather than absolute values
2017-03-20 Reduced the number of Serial.print() commands by using a char buffer and snprintf
2017-03-20 DELAY_TIME -> SWITCH_DELAY_TIME
2017-03-20 Started implenenting mocked objects for tests
2017-03-20 Added working makefile, had to move a few files around
2017-03-20 removed test_definitions.h from makefile
2017-03-20 Removed unused files
2017-03-20 Added basic test for phase word
2017-03-20 More thorough testing of Set_Phase
2017-03-20 Minor comment change
2017-03-20 Refactored for better testing
2017-03-20 Added tests for frequency programming
2017-03-20 Updated .gitignore
2017-03-20 Deleted empty docs folder
2017-03-21 Replaced numeric constants in Program_DDS with defines
2017-03-21 Few changes to comments
2017-03-21 Moved final step for setting msb and lsb inside their respective functions
2017-03-21 Updated comments
2017-03-21 Moved print statements from main script to functions
2017-03-21 Fixed deprecated conversion from string constant to 'char* warning
2017-03-21 Changed arduino.h #ifndef to be consistent with other .h files
2017-03-21 Changed #include <iostream> to <stdio.h> to (hopefully) fix travis issue
2017-03-21 Changed %d to %ld for printing long int value
2017-03-21 Update comments
2017-03-21 Updated makefile
2017-03-21 Renamed test file to run_tests
2017-03-21 Removed old schematics
2017-03-21 Don't checkout master
2017-03-22 Added image to README
2017-03-23 Fix indentation
2017-07-06 Started new connector board with high pass filter
2017-07-07 added sim of DC blocking circuit
2017-07-07 changed sim to virtual ground version
2017-07-10 Added parts for 2 channels
2017-07-10 example layout for 4 channels
2017-07-10 now passing ERC
2017-07-10 Duplicated layout through renaming parts
2017-07-11 12 chn board finished
2017-07-11 added drill holes and gerbers
2017-07-13 version sent to PCBtrain. Simulations added also
2017-07-17 AD9954 current source design. No ERC and DRC violations
2017-07-17 Final layout tweaks done and Gerbers generated
2017-07-18 Version before adding 32 channels
2017-07-21 Renaming Sch and Brd but not matching yet
2017-07-21 brd and sch match
2017-07-24 Grounded input to test noise, this prevents 50Hz crosstalk when channel not in use
2017-07-24 switched bypass caps to 0402
2017-07-24 Added Input resistor to ground. Started routing Dsub out
2017-07-25 Finished dsub out and GND routing. Starting V planes
2017-07-26 Finished PWR GND
2017-07-26 Most of pins to AMPs routed
2017-07-27 Schematic and PCB desig for AD9954 low noise current source
2017-07-27 Finished Routing and First BOM
2017-07-27 Finished Board
2017-07-31 finished board with Gerbers and Info for PCBTrain
2017-08-14 fixed BOM
2017-09-07 started case design
2017-09-07 fixed wrong orientation on -ve led
2017-09-08 Added case
2017-09-21 Fiddling with the case design
2017-10-03 Added sanity check for data with Parallel system
2017-10-03 Frequencies on Anna Hospital PC
2017-10-11 freq adjustment and added Voltage output to sanity check
2017-11-29 fixed bug not reporting using chn labels
2017-11-29 speed up processing with lower order filt
2018-02-06 1st update for newest parallel board
2018-02-08 latest case and schematic for EEG board
2018-02-13 Added buffered ground
2018-02-14 Added battery charger and Voltage inverter
2018-02-15 Inital board layout for Voltage inverter and battery charger
2018-02-15 bom for quote
2018-02-19 removed lib autosaved
2018-02-19 final gerbers sent to PCBway
2018-02-28 fixed error where inner layer gerbers werent updated
2018-03-01 Added code for programming mini CS and ADG731 switches
2018-03-13 13/3/18
2018-03-20 20/3/18
2018-03-20 Removed unneeded switching code
2018-03-20 Tidying up
2018-03-22 Removed switching codd
2018-04-13 updates to check eit for better handling on pycorder files with parallel system
2018-10-08 Anna's computer
    Working with Hospital carbon
2019-03-07 Pro Micro pins fixed
    Fixed pin-out for pro micro VS pro mini
