# Repository EIT-team/Parallel-CS

File README.md:

# Parallel-CS
Parallel inject current source schematic and programming code, using AD9833 DDS IC.

Includes: Circuit schematics, PCB Layout, Arduino code for programming output frequency and/or phase of CS.

**Instructions for programming CS board**

- Turn on power (Press both push button switches).
- Connect mini-USB cable to Arduino.
- Open /src/DDS_PCB/DDS_PCB.ino and upload to Arduino.

Devices will be initially be programmed to default frequencies, specified in the src/frequencies.h file.

After programming, frequency and/or phase can be adjusted using serial monitor:
- Open serial monitor (Ctrl-Shift-M)
- Make sure line ending is set to '_no line ending_' and baud rate is 9600
- '_freq chan value_' will set the frequency of _chan_ to _value_ e.g. '_freq 2 2500_' sets channel 2 to 2500Hz
- '_phase chan value_' will set the phase in degrees of _chan_ to _value_ e.g. '_phase 2 50_' sets phase of channel 2 to 50 degrees. Phase is 0 by default.
- The terminal should echo a message confirming programming is happening.

Once programmed, the USB cable can be unplugged.

## EAGLE design schematics/Connector.Filter.Board/Connector.Board.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72: 0.1uF; C0402
C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C73, C74, C75, C76, C77, C78, C79, C80: 1uf; C0805
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 1M; R0402
R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64: 1.6M; R0805
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32: TOUCHPROOF; TOUCHPROOF_PIN
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24: AD8244; MSOP10
X1: EEGCON; M37HP
X2: EITCON; F37HP

Connections:
BUF1: C19.1, U5.2 (OUT_A), U6.2 (OUT_A)
BUF2: C20.1, U5.4 (OUT_B), U6.4 (OUT_B)
BUF3: C21.1, U6.9 (OUT_C), U9.9 (OUT_C)
BUF4: C22.1, U6.7 (OUT_D), U9.7 (OUT_D)
BUF5: C23.1, U1.2 (OUT_A), U2.2 (OUT_A)
BUF6: C24.1, U1.4 (OUT_B), U2.4 (OUT_B)
BUF7: C25.1, U2.9 (OUT_C), U7.9 (OUT_C)
BUF8: C26.1, U2.7 (OUT_D), U7.7 (OUT_D)
BUF9: C27.1, U3.2 (OUT_A), U4.2 (OUT_A)
BUF10: C28.1, U3.4 (OUT_B), U4.4 (OUT_B)
BUF11: C29.1, U4.9 (OUT_C), U8.9 (OUT_C)
BUF12: C30.1, U4.7 (OUT_D), U8.7 (OUT_D)
BUF13: C49.1, U14.2 (OUT_A), U15.2 (OUT_A)
BUF14: C50.1, U14.4 (OUT_B), U15.4 (OUT_B)
BUF15: C51.1, U15.9 (OUT_C), U18.9 (OUT_C)
BUF16: C52.1, U15.7 (OUT_D), U18.7 (OUT_D)
BUF17: C53.1, U10.2 (OUT_A), U11.2 (OUT_A)
BUF18: C54.1, U10.4 (OUT_B), U11.4 (OUT_B)
BUF19: C55.1, U11.9 (OUT_C), U16.9 (OUT_C)
BUF20: C56.1, U11.7 (OUT_D), U16.7 (OUT_D)
BUF21: C57.1, U12.2 (OUT_A), U13.2 (OUT_A)
BUF22: C58.1, U12.4 (OUT_B), U13.4 (OUT_B)
BUF23: C59.1, U13.9 (OUT_C), U17.9 (OUT_C)
BUF24: C60.1, U13.7 (OUT_D), U17.7 (OUT_D)
BUF25: C73.1, U21.2 (OUT_A), U22.2 (OUT_A)
BUF26: C74.1, U21.4 (OUT_B), U22.4 (OUT_B)
BUF27: C75.1, U22.9 (OUT_C), U24.9 (OUT_C)
BUF28: C76.1, U22.7 (OUT_D), U24.7 (OUT_D)
BUF29: C77.1, U19.2 (OUT_A), U20.2 (OUT_A)
BUF30: C78.1, U19.4 (OUT_B), U20.4 (OUT_B)
BUF31: C79.1, U20.9 (OUT_C), U23.9 (OUT_C)
BUF32: C80.1, U20.7 (OUT_D), U23.7 (OUT_D)
FILT1_BUF: U5.7 (OUT_D), X1.1
FILT1_OUT: C19.2, R33.2, U5.6 (IN_D)
FILT2_BUF: U5.9 (OUT_C), X1.2
FILT2_OUT: C20.2, R34.2, U5.10 (IN_C)
FILT3_BUF: U9.2 (OUT_A), X1.3
FILT3_OUT: C21.2, R35.2, U9.1 (IN_A)
FILT4_BUF: U9.4 (OUT_B), X1.4
FILT4_OUT: C22.2, R36.2, U9.5 (IN_B)
FILT5_BUF: U1.7 (OUT_D), X1.5
FILT5_OUT: C23.2, R37.2, U1.6 (IN_D)
FILT6_BUF: U1.9 (OUT_C), X1.6
FILT6_OUT: C24.2, R38.2, U1.10 (IN_C)
FILT7_BUF: U7.2 (OUT_A), X1.7
FILT7_OUT: C25.2, R39.2, U7.1 (IN_A)
FILT8_BUF: U7.4 (OUT_B), X1.8
FILT8_OUT: C26.2, R40.2, U7.5 (IN_B)
FILT9_BUF: U3.7 (OUT_D), X1.9
FILT9_OUT: C27.2, R41.2, U3.6 (IN_D)
FILT10_BUF: U3.9 (OUT_C), X1.10
FILT10_OUT: C28.2, R42.2, U3.10 (IN_C)
FILT11_BUF: U8.2 (OUT_A), X1.11
FILT11_OUT: C29.2, R43.2, U8.1 (IN_A)
FILT12_BUF: U8.4 (OUT_B), X1.12
FILT12_OUT: C30.2, R44.2, U8.5 (IN_B)
FILT13_BUF: U14.7 (OUT_D), X1.13
FILT13_OUT: C49.2, R45.2, U14.6 (IN_D)
FILT14_BUF: U14.9 (OUT_C), X1.14
FILT14_OUT: C50.2, R46.2, U14.10 (IN_C)
FILT15_BUF: U18.2 (OUT_A), X1.15
FILT15_OUT: C51.2, R47.2, U18.1 (IN_A)
FILT16_BUF: U18.4 (OUT_B), X1.16
FILT16_OUT: C52.2, R48.2, U18.5 (IN_B)
FILT17_BUF: U10.7 (OUT_D), X1.17
FILT17_OUT: C53.2, R49.2, U10.6 (IN_D)
FILT18_BUF: U10.9 (OUT_C), X1.18
FILT18_OUT: C54.2, R50.2, U10.10 (IN_C)
FILT19_BUF: U16.2 (OUT_A), X1.19
FILT19_OUT: C55.2, R51.2, U16.1 (IN_A)
FILT20_BUF: U16.4 (OUT_B), X1.20
FILT20_OUT: C56.2, R52.2, U16.5 (IN_B)
FILT21_BUF: U12.7 (OUT_D), X1.21
FILT21_OUT: C57.2, R53.2, U12.6 (IN_D)
FILT22_BUF: U12.9 (OUT_C), X1.22
FILT22_OUT: C58.2, R54.2, U12.10 (IN_C)
FILT23_BUF: U17.2 (OUT_A), X1.23
FILT23_OUT: C59.2, R55.2, U17.1 (IN_A)
FILT24_BUF: U17.4 (OUT_B), X1.24
FILT24_OUT: C60.2, R56.2, U17.5 (IN_B)
FILT25_BUF: U21.7 (OUT_D), X1.25
FILT25_OUT: C73.2, R57.2, U21.6 (IN_D)
FILT26_BUF: U21.9 (OUT_C), X1.26
FILT26_OUT: C74.2, R58.2, U21.10 (IN_C)
FILT27_BUF: U24.2 (OUT_A), X1.27
FILT27_OUT: C75.2, R59.2, U24.1 (IN_A)
FILT28_BUF: U24.4 (OUT_B), X1.28
FILT28_OUT: C76.2, R60.2, U24.5 (IN_B)
FILT29_BUF: U19.7 (OUT_D), X1.29
FILT29_OUT: C77.2, R61.2, U19.6 (IN_D)
FILT30_BUF: U19.9 (OUT_C), X1.30
FILT30_OUT: C78.2, R62.2, U19.10 (IN_C)
FILT31_BUF: U23.2 (OUT_A), X1.31
FILT31_OUT: C79.2, R63.2, U23.1 (IN_A)
FILT32_BUF: U23.4 (OUT_B), X1.32
FILT32_OUT: C80.2, R64.2, U23.5 (IN_B)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1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; also elsewhere on the board
PIN1: R1.2, TP1.TP, U5.1 (IN_A), U6.1 (IN_A), X2.1
PIN2: R9.2, TP2.TP, U5.5 (IN_B), U6.5 (IN_B), X2.2
PIN3: R17.2, TP3.TP, U6.10 (IN_C), U9.10 (IN_C), X2.3
PIN4: R25.2, TP4.TP, U6.6 (IN_D), U9.6 (IN_D), X2.4
PIN5: R2.2, TP5.TP, U1.1 (IN_A), U2.1 (IN_A), X2.5
PIN6: R10.2, TP6.TP, U1.5 (IN_B), U2.5 (IN_B), X2.6
PIN7: R18.2, TP7.TP, U2.10 (IN_C), U7.10 (IN_C), X2.7
PIN8: R26.2, TP8.TP, U2.6 (IN_D), U7.6 (IN_D), X2.8
PIN9: R3.2, TP9.TP, U3.1 (IN_A), U4.1 (IN_A), X2.9
PIN10: R11.2, TP10.TP, U3.5 (IN_B), U4.5 (IN_B), X2.10
PIN11: R19.2, TP11.TP, U4.10 (IN_C), U8.10 (IN_C), X2.11
PIN12: R27.2, TP12.TP, U4.6 (IN_D), U8.6 (IN_D), X2.12
PIN13: R4.2, TP13.TP, U14.1 (IN_A), U15.1 (IN_A), X2.13
PIN14: R12.2, TP14.TP, U14.5 (IN_B), U15.5 (IN_B), X2.14
PIN15: R20.2, TP15.TP, U15.10 (IN_C), U18.10 (IN_C), X2.15
PIN16: R28.2, TP16.TP, U15.6 (IN_D), U18.6 (IN_D), X2.16
PIN17: R5.2, TP17.TP, U10.1 (IN_A), U11.1 (IN_A), X2.17
PIN18: R13.2, TP18.TP, U10.5 (IN_B), U11.5 (IN_B), X2.18
PIN19: R21.2, TP19.TP, U11.10 (IN_C), U16.10 (IN_C), X2.19
PIN20: R29.2, TP20.TP, U11.6 (IN_D), U16.6 (IN_D), X2.20
PIN21: R6.2, TP21.TP, U12.1 (IN_A), U13.1 (IN_A), X2.21
PIN22: R14.2, TP22.TP, U12.5 (IN_B), U13.5 (IN_B), X2.22
PIN23: R22.2, TP23.TP, U13.10 (IN_C), U17.10 (IN_C), X2.23
PIN24: R30.2, TP24.TP, U13.6 (IN_D), U17.6 (IN_D), X2.24
PIN25: R7.2, TP25.TP, U21.1 (IN_A), U22.1 (IN_A), X2.25
PIN26: R15.2, TP26.TP, U21.5 (IN_B), U22.5 (IN_B), X2.26
PIN27: R23.2, TP27.TP, U22.10 (IN_C), U24.10 (IN_C), X2.27
PIN28: R31.2, TP28.TP, U22.6 (IN_D), U24.6 (IN_D), X2.28
PIN29: R8.2, TP29.TP, U19.1 (IN_A), U20.1 (IN_A), X2.29
PIN30: R16.2, TP30.TP, U19.5 (IN_B), U20.5 (IN_B), X2.30
PIN31: R24.2, TP31.TP, U20.10 (IN_C), U23.10 (IN_C), X2.31
PIN32: R32.2, TP32.TP, U20.6 (IN_D), U23.6 (IN_D), X2.32
V+: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C16.1, C17.1, C18.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C46.1, C47.1, C48.1, C65.1, C66.1, C67.1, C68.1, C71.1, C72.1, U1.3 (V+), U2.3 (V+), U3.3 (V+), U4.3 (V+), U5.3 (V+), U6.3 (V+), U7.3 (V+), U8.3 (V+), U9.3 (V+), U10.3 (V+), U11.3 (V+), U12.3 (V+), U13.3 (V+), U14.3 (V+), U15.3 (V+), U16.3 (V+), U17.3 (V+), U18.3 (V+), U19.3 (V+), U20.3 (V+), U21.3 (V+), U22.3 (V+), U23.3 (V+), U24.3 (V+); also elsewhere on the board
V-: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C13.1, C14.1, C15.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C43.1, C44.1, C45.1, C61.1, C62.1, C63.1, C64.1, C69.1, C70.1, U1.8 (V-), U2.8 (V-), U3.8 (V-), U4.8 (V-), U5.8 (V-), U6.8 (V-), U7.8 (V-), U8.8 (V-), U9.8 (V-), U10.8 (V-), U11.8 (V-), U12.8 (V-), U13.8 (V-), U14.8 (V-), U15.8 (V-), U16.8 (V-), U17.8 (V-), U18.8 (V-), U19.8 (V-), U20.8 (V-), U21.8 (V-), U22.8 (V-), U23.8 (V-), U24.8 (V-); also elsewhere on the board

Notes on the sheet:
TODO: Check if we want male or female D Sub

Parts:
C81, C82: 2.2uF; C0805
C83, C84: 0.1uF; C0402
C85, C86: 10nF; C0402
C92, C93, C94: 10uF; C0805
D1, D2: 1N4148W-7-F; SOD123
JP5: IN; 1X02
LED1, LED2: RED; SML0805
LED3: YELLOW; SML0805
LED4: GREEN; SML0805
R65, R66, R69: 1k; R0402
R67: 2k; R0402
R68: 470; R0402
S1: PVA1F
U27: MCP73831; SOT23-5
U28: LTC1044ACS8PBF; SOIC127P600X175-8N
X3: 47346-0001; MOLEX_47346-0001
X7: JST-XH-02-PIN-LONG-PAD; JST-XH-02-PACKAGE-LONG-PAD

Connections:
5VIN: C92.1, D1.C, JP5.1, LED3.A, U27.4 (VIN), X3.1
BOOST: U28.1 (BOOST)
CHRG: LED3.C, R68.2
GND: C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C92.2, C94.2, D1.A, D2.A, JP5.2, LED4.C, R65.1, R66.2, R67.1, U27.2 (VSS), U28.3 (GROUND), X3.5, X7.1; also elsewhere on the board
unnamed: LED2.A, R66.1
unnamed: C93.1, U28.2 (CAP+)
unnamed: C93.2, U28.4 (CAP-)
unnamed: LED4.A, R69.2
unnamed: LED1.C, R65.2
PROG: R67.2, U27.5 (PROG)
STAT: R68.1, R69.1, U27.1 (STAT)
V+: C81.1, C83.1, C85.1, LED1.A, S1.1 (S), U28.8 (V+); also elsewhere on the board
V-: C82.1, C84.1, C86.1, C94.1, LED2.C, U28.5 (VOUT); also elsewhere on the board
VBATT_A: D2.C, S1.2, U27.3 (VBAT), X7.2

Notes on the sheet:
BATTERY CHARGER
2K R programs for 500mA output (i think this is most efficient)

Parts:
C87, C88, C89, C90: 0.1uF; C0402
PAT_GND, PAT_GND1, PAT_GND2: TOUCHPROOF; TOUCHPROOF_PIN
U25, U26: AD8244; MSOP10

Connections:
GND: C87.2, C88.2, C89.2, C90.2, U25.1 (IN_A), U25.5 (IN_B), U25.6 (IN_D), U25.10 (IN_C), U26.1 (IN_A), U26.5 (IN_B), U26.6 (IN_D), U26.10 (IN_C); also elsewhere on the board
PAT_GND: PAT_GND.TP, PAT_GND1.TP, PAT_GND2.TP, U25.2 (OUT_A), U25.4 (OUT_B), U25.7 (OUT_D), U25.9 (OUT_C), U26.2 (OUT_A), U26.4 (OUT_B), U26.7 (OUT_D), U26.9 (OUT_C)
V+: C87.1, C89.1, U25.3 (V+), U26.3 (V+); also elsewhere on the board
V-: C88.1, C90.1, U25.8 (V-), U26.8 (V-); also elsewhere on the board

Board: 4 copper layers, 192.0 x 73.3 mm, 237 parts (77 on the bottom side), 142 nets.

File schematics/Connector.Filter.Board/Connector_Board_BOM.csv (part):

"Part";"Value";"Device";"Package";"Description";"BTM_NEG";"BTM_POS";"MF";"MPN";"OC_FARNELL";"OC_NEWARK";"PROD_ID";"TOP_NEG";"TOP_POS";"TP_SIGNAL_NAME";
"C1";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C2";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C3";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C4";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C5";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C6";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C7";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C8";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C9";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C10";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C11";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C12";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C13";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C14";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C15";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C16";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C17";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C18";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C19";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C20";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C21";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C22";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C23";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C24";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C25";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C26";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C27";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C28";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C29";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C30";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C31";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C32";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C33";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C34";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C35";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C36";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C37";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C38";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C39";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C40";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C41";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C42";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C43";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C44";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C45";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C46";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C47";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C48";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C49";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C50";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C51";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C52";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C53";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C54";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C55";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C56";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C57";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C58";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C59";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C60";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C61";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C62";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C63";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C64";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C65";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C66";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C67";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C68";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C69";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C70";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C71";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C72";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C73";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C74";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C75";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C76";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C77";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C78";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C79";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C80";"1uf";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C81";"2.2uF";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C82";"2.2uF";"C-EUC0805";"C0805";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C83";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
"C84";"0.1uF";"C-EUC0402";"C0402";"CAPACITOR, European symbol";"";"";"";"";"";"";"";"";"";"";
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

Notices in the files:
parts and their libraries:
SparkFun-PowerIC: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
