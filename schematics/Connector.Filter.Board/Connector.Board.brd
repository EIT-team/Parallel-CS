# Repository EIT-team/Parallel-CS (continued)

## EAGLE design schematics/Connector.Filter.Board/Gnd_iso.brd

Parts:
C1, C2, C3, C4: 0.1uF; C0805
JP1, JP2, JP3: PINHD-1X2/90; 1X02/90
U1, U2: AD8244; MSOP10

Connections:
GND: C1.2, C2.2, C3.2, C4.2, JP1.2, JP2.2, U1.1 (IN_A), U1.5 (IN_B), U1.6 (IN_D), U1.10 (IN_C), U2.1 (IN_A), U2.5 (IN_B), U2.6 (IN_D), U2.10 (IN_C)
PAT_GND: JP3.1, JP3.2, U1.2 (OUT_A), U1.4 (OUT_B), U1.7 (OUT_D), U1.9 (OUT_C), U2.2 (OUT_A), U2.4 (OUT_B), U2.7 (OUT_D), U2.9 (OUT_C)
V+: C2.1, C4.1, JP1.1, U1.3 (V+), U2.3 (V+)
V-: C1.1, C3.1, JP2.1, U1.8 (V-), U2.8 (V-)

Board: 2 copper layers, 18.8 x 14.6 mm, 9 parts (3 on the bottom side), 4 nets.

## EAGLE design schematics/Rev.Jan.2017/Parallel CS V5.brd

Parts:
CLOCK: LTC69000; SOT23-5L
C_CLK_BYP: 0.1u; C0805
JP+: PWR; JST-2-SMD
JP-: PWR; JST-2-SMD
LED_VDD: LEDSML0805; SML0805
LED_VSS: LEDSML0805; SML0805
R1, R3, R5, R7, R9, R10: 10k; R0805
R2, R4, R6, R8, R12, R13: 20k; R0805
R11: 1.5k; R0805
R_SET: 20k; R0805
R_VDD_LED: 1k; M0805
R_VSS_LED: 1k; M0805
S1, S2: PVA1F
TP_MCLK: PTR1PAD1-13; P1-13
TP_SCLK: PTR1PAD1-13; P1-13
TP_SDATA: PTR1PAD1-13; P1-13
TP_VDD: PTR1PAD1-13; P1-13
TP_VSS: PTR1PAD1-13; P1-13
U1: ADG714BRUZ; SOP65P640X120-24N
U$1: NANO

Connections:
CLK_OUT: CLOCK.5 (OUT), TP_MCLK.TP; also elsewhere on the board
DDS_SCLK: R1.1, R2.2, TP_SCLK.TP; also elsewhere on the board
DDS_SCLK_5V: R1.2, U$1.D13
DDS_SDATA: R3.1, R4.2, TP_SDATA.TP; also elsewhere on the board
FSYNC_CS1: U1.6 (D1); also elsewhere on the board
FSYNC_CS2: U1.8 (D2)
FSYNC_CS3: U1.10 (D3)
FSYNC_CS4: U1.12 (D4)
FSYNC_CS5: U1.13 (D5)
FSYNC_CS6: U1.15 (D6)
FSYNC_CS7: U1.17 (D7)
FSYNC_CS8: U1.19 (D8)
FSYNC_IN: R11.2, U1.5 (S1), U1.7 (S2), U1.9 (S3), U1.11 (S4), U1.14 (S5), U1.16 (S6), U1.18 (S7), U1.20 (S8)
FSYNC_IN_5V: R11.1, U$1.D5
GND: CLOCK.2 (GND), CLOCK.4 (DIV), C_CLK_BYP.2, LED_VDD.C, LED_VSS.C, R2.1, R4.1, R6.2, R8.2, R12.1, R13.1, S1.3 (S), S2.1 (S), U1.4 (GND), U1.21 (VSS), U$1.GND; also elsewhere on the board
unnamed: CLOCK.3 (SET), R_SET.2
unnamed: JP+.2, S1.2
unnamed: JP+.1, S1.4
unnamed: JP-.2, S2.2
unnamed: JP-.1, S2.4
unnamed: LED_VDD.A, R_VDD_LED.1
unnamed: LED_VSS.A, R_VSS_LED.1
unnamed: R3.2, U$1.D11
SW_DIN: R7.2, R8.1, U1.3 (DIN)
SW_DIN_5V: R7.1, U$1.D4
SW_SCLK: R5.2, R6.1, U1.1 (SCLK)
SW_SCLK_5V: R5.1, U$1.D9
SW_~RESET: R10.2, R13.2, U1.23 (~RESET)
SW_~RESET_5V: R10.1, U$1.D3
SW_~SYNC: R9.2, R12.2, U1.24 (~SYNC)
SW_~SYNC_5V: R9.1, U$1.D2
VDD: CLOCK.1 (V+), C_CLK_BYP.1, R_SET.1, R_VDD_LED.2, S1.1 (S), TP_VDD.TP, U1.2 (VDD); also elsewhere on the board
VSS: R_VSS_LED.2, S2.3 (S), TP_VSS.TP; also elsewhere on the board

Notes on the sheet:
Switch to route FSYNC to each CS
5V from Arduino needs to be convertred to ~3.3V to set the right levels for the DDS & Switch ICs, which are powered by 3.7V batteries. Hence resistor dividers.
Battery Connector & Power LEDs
Clock output Freq = 10MHz * 20k/R_set
Arduino Socket
Test Points
Left floating - is routed to the FSYNC pins of DDS chips which have a resistor to GND to form a potential divider, giving the correct voltage level for DDS IC

Parts:
C_DDS1: 0.1u; C0805
C_DDS2: 10u; C0805
C_DDS3: 10n; C0805
C_DDS4: 100n; C0805
C_DECOUP: 1u; C0805
C_OPA1, C_OPA2: 0.1u; C0805
C_OPB1, C_OPB2: 0.1u; C0805
C_OPC1, C_OPC2: 0.1u; C0805
C_OPD1, C_OPD2: 0.1u; C0805
DDS: AD9833BRMZ; SOP50P490X110-10N
JP_OUT: JP1Q; JP1
OP_GAIN: RC4560S08-RC4560; SO8
OP_HOWLA: RC4560S08-RC4560; SO8
OP_HOWLB: RC4560S08-RC4560; SO8
OP_S2D: RC4560S08-RC4560; SO8
R_DECOUP: 10k; R0805
R_GAIN1: 10k; R0805
R_GAIN2: 1; R0805
R_GAINF: POTENTIOMETER_PT-10; PT-10
R_HOWA1, R_HOWA2, R_HOWA3, R_HOWA4: 100k; R0805
R_HOWA5: 10k; R0805
R_HOWB1, R_HOWB2, R_HOWB3, R_HOWB5: 100k; R0805
R_HOWB4: 10k; R0805
R_PULLDOWN: 20k; R0805
R_S2D1, R_S2D2, R_S2D3, R_S2D4: 10k; R0805
TP_FSYNC: PTR1PAD1-13; P1-13
TP_GND: PTR1PAD1-13; P1-13
TP_VSIN, TP_VSIN1, TP_VSIN2, TP_VSIN3: PTR1PAD1-13; P1-13

Connections:
CLK_OUT: DDS.5 (MCLK); also elsewhere on the board
COMP: C_DDS3.2, DDS.1 (COMP)
DDS_SCLK: DDS.7 (SCLK); also elsewhere on the board
DDS_SDATA: DDS.6 (SDATA); also elsewhere on the board
FSYNC_CS1: DDS.8 (FSYNC), R_PULLDOWN.2, TP_FSYNC.TP; also elsewhere on the board
GND: C_DDS1.2, C_DDS2.2, C_DDS4.1, C_OPA1.2, C_OPA2.2, C_OPB1.2, C_OPB2.2, C_OPC1.2, C_OPC2.2, C_OPD1.2, C_OPD2.2, DDS.4 (DGND), DDS.9 (AGND), R_DECOUP.2, R_GAIN1.1, R_PULLDOWN.1, R_S2D2.2, TP_GND.TP; also elsewhere on the board
unnamed: C_DDS4.2, DDS.3 (CAP/2.5V)
unnamed: OP_GAIN.1 (OUTA), R_GAIN2.1, R_GAINF.3, R_S2D3.2, R_S2D4.2, TP_VSIN1.TP
unnamed: OP_S2D.6 (NEGB), OP_S2D.7 (OUTB), R_HOWA1.2, R_HOWB1.2, TP_VSIN3.TP
unnamed: OP_GAIN.2 (NEGA), R_GAIN1.2, R_GAIN2.2, R_GAINF.1
unnamed: OP_S2D.5 (POSB), R_S2D4.1
unnamed: OP_HOWLA.5 (POSB), R_HOWA1.1, R_HOWA3.1
unnamed: OP_S2D.3 (POSA), R_S2D2.1
unnamed: OP_S2D.2 (NEGA), R_S2D1.2, R_S2D3.1
unnamed: OP_HOWLB.3 (POSA), R_HOWB2.1, R_HOWB3.1
unnamed: OP_HOWLB.2 (NEGA), R_HOWB1.1, R_HOWB5.1
unnamed: JP_OUT.2, R_HOWB3.2, R_HOWB4.1
unnamed: JP_OUT.1, R_HOWA3.2, R_HOWA5.2
unnamed: OP_HOWLA.7 (OUTB), R_HOWA4.1, R_HOWA5.1
unnamed: OP_HOWLA.6 (NEGB), R_HOWA2.1, R_HOWA4.2
unnamed: OP_HOWLB.1 (OUTA), R_HOWB4.2, R_HOWB5.2
unnamed: OP_S2D.1 (OUTA), R_HOWA2.2, R_HOWB2.2, R_S2D1.1, TP_VSIN2.TP
VDD: C_DDS1.1, C_DDS2.1, C_DDS3.1, C_OPA1.1, C_OPB1.1, C_OPC1.1, C_OPD1.1, DDS.2 (VDD), OP_GAIN.8 (V+), OP_HOWLA.8 (V+), OP_HOWLB.8 (V+), OP_S2D.8 (V+); also elsewhere on the board
VOUT: C_DECOUP.1, DDS.10 (VOUT), TP_VSIN.TP
VSIN: C_DECOUP.2, OP_GAIN.3 (POSA), R_DECOUP.1
VSS: C_OPA2.1, C_OPB2.1, C_OPC2.1, C_OPD2.1, OP_GAIN.4 (V-), OP_HOWLA.4 (V-), OP_HOWLB.4 (V-), OP_S2D.4 (V-); also elsewhere on the board

Notes on the sheet:
DDS Chip, programmed by SPI
Howland Current Pump Using two separate ICs for medical safety to cover case where a single device fails.
Power Bypass Caps for Op Amps
Gain Stage Can either put in fixed resistor (R_gain2) or potentiometer for setting gain
Single ended to differential

Board: 4 copper layers, 99.9 x 150.1 mm, 75 parts (0 on the bottom side), 45 nets.

## EAGLE design schematics/Rev.3.May.2016/Parallel CS V3.brd

Parts:
CLOCK: LTC69000; SOT23-5L
C_CLK_BYP: 0.1u; C0805
JP1, JP33: PWR; 1X02
R1, R3: 10k; R0805
R2, R4: 20k; R0603
R_SET: 20k; R0603
TP_D1, TP_D2, TP_D3, TP_D4, TP_D5, TP_D6, TP_D7, TP_D8: PTR1PAD1-13; P1-13
TP_GND_CON, TP_GND_CON1: PTR1PAD1-13; P1-13
TP_MCLK, TP_MCLK1: PTR1PAD1-13; P1-13
TP_SCLK, TP_SCLK1: PTR1PAD1-13; P1-13
TP_SDATA, TP_SDATA1: PTR1PAD1-13; P1-13
TP_VDD, TP_VDD1: PTR1PAD1-13; P1-13
TP_VSS, TP_VSS1: PTR1PAD1-13; P1-13
U1: ADG714BRUZ; SOP65P640X120-24N
X2: CTR_ARD; F09HP

Connections:
CLK_OUT: CLOCK.5 (OUT), TP_MCLK.TP, TP_MCLK1.TP; also elsewhere on the board
DDS_SCLK: R1.1, R2.2, TP_SCLK.TP, TP_SCLK1.TP; also elsewhere on the board
DDS_SCLK_5V: R1.2, X2.3
DDS_SDATA: R3.1, R4.2, TP_SDATA.TP, TP_SDATA1.TP; also elsewhere on the board
DDS_SDATA_5V: R3.2, X2.2
FSYNC_CS1: TP_D1.TP, U1.6 (D1)
FSYNC_CS2: TP_D2.TP, U1.8 (D2)
FSYNC_CS3: TP_D3.TP, U1.10 (D3)
FSYNC_CS4: TP_D4.TP, U1.12 (D4)
FSYNC_CS5: TP_D5.TP, U1.13 (D5)
FSYNC_CS6: TP_D6.TP, U1.15 (D6)
FSYNC_CS7: TP_D7.TP, U1.17 (D7)
FSYNC_CS8: TP_D8.TP, U1.19 (D8)
FSYNC_IN: U1.5 (S1), U1.7 (S2), U1.9 (S3), U1.11 (S4), U1.14 (S5), U1.16 (S6), U1.18 (S7), U1.20 (S8), X2.9
GND: CLOCK.2 (GND), CLOCK.4 (DIV), C_CLK_BYP.2, JP1.2, JP33.1, R2.1, R4.1, TP_GND_CON.TP, TP_GND_CON1.TP, U1.4 (GND), U1.21 (VSS), X2.6; also elsewhere on the board
unnamed: CLOCK.3 (SET), R_SET.2
SW_DIN: U1.3 (DIN), X2.5
SW_SCLK: U1.1 (SCLK), X2.1
SW_~RESET: U1.23 (~RESET), X2.8
SW_~SYNC: U1.24 (~SYNC), X2.7
VDD: CLOCK.1 (V+), C_CLK_BYP.1, JP33.2, R_SET.1, TP_VDD.TP, TP_VDD1.TP, U1.2 (VDD); also elsewhere on the board
VSS: JP1.1, TP_VSS.TP, TP_VSS1.TP; also elsewhere on the board

Notes on the sheet:
Switch to route FSYNC, powered by Arduino
DSUB FROM ARDUINO
Battery Connector
Clock output Freq = 10MHz * 20k/R_set

Parts:
C_DDS1: 0.1u; C0805
C_DDS2: 10u; C0805
C_DDS3: 10n; C0805
C_DDS4: 100n; C0805
C_OPA1, C_OPA2: 0.1u; C0805
C_OPB1, C_OPB2: 0.1u; C0805
C_OPC1, C_OPC2: 0.1u; C0805
C_VSIN_OUT: 1u; C0805
DDS: AD9833BRMZ; SOP50P490X110-10N
JP_OUT: JP1Q; JP1
OP_GAIN: RC4560; DIL08
OP_HOWL: RC4560; DIL08
OP_S2D: RC4560; DIL08
R_GAIN1: 10k; R0805
R_GAINF: POTENTIOMETER_PT-10; PT-10
R_HOW1, R_HOW2, R_HOW3, R_HOW4, R_HOW5, R_HOW6, R_HOW7, R_HOW8: 10k; R0805
R_S2D1, R_S2D2, R_S2D3, R_S2D4: 10k; R0805
TP_FSYNC: PTR1PAD1-13; P1-13
TP_GND: PTR1PAD1-13; P1-13
TP_VSIN, TP_VSIN1, TP_VSIN2, TP_VSIN3: PTR1PAD1-13; P1-13

Connections:
CLK_OUT: DDS.5 (MCLK); also elsewhere on the board
COMP: C_DDS3.2, DDS.1 (COMP)
DDS_SCLK: DDS.7 (SCLK); also elsewhere on the board
DDS_SDATA: DDS.6 (SDATA); also elsewhere on the board
FSYNC: DDS.8 (FSYNC), TP_FSYNC.TP
GND: C_DDS1.2, C_DDS2.2, C_DDS4.1, C_OPA1.2, C_OPA2.2, C_OPB1.2, C_OPB2.2, C_OPC1.2, C_OPC2.2, DDS.4 (DGND), DDS.9 (AGND), R_GAIN1.1, R_S2D2.2, TP_GND.TP; also elsewhere on the board
unnamed: C_DDS4.2, DDS.3 (CAP/2.5V)
unnamed: OP_GAIN.1 (OUTA), R_GAINF.3, R_S2D3.2, R_S2D4.2, TP_VSIN1.TP
unnamed: OP_S2D.6 (NEGB), OP_S2D.7 (OUTB), R_HOW2.2, R_HOW3.2, TP_VSIN3.TP
unnamed: OP_GAIN.2 (NEGA), R_GAIN1.2, R_GAINF.1
unnamed: OP_S2D.5 (POSB), R_S2D4.1
unnamed: OP_S2D.1 (OUTA), R_HOW1.2, R_HOW4.2, R_S2D1.1, TP_VSIN2.TP
unnamed: OP_S2D.3 (POSA), R_S2D2.1
unnamed: OP_S2D.2 (NEGA), R_S2D1.2, R_S2D3.1
unnamed: OP_HOWL.2 (NEGA), R_HOW3.1, R_HOW6.1
unnamed: JP_OUT.2, OP_HOWL.3 (POSA), R_HOW1.1, R_HOW5.1
unnamed: JP_OUT.1, OP_HOWL.5 (POSB), R_HOW2.1, R_HOW8.2
unnamed: OP_HOWL.1 (OUTA), R_HOW5.2, R_HOW6.2
unnamed: OP_HOWL.7 (OUTB), R_HOW7.1, R_HOW8.1
unnamed: OP_HOWL.6 (NEGB), R_HOW4.1, R_HOW7.2
VDD: C_DDS1.1, C_DDS2.1, C_DDS3.1, C_OPA1.1, C_OPB1.1, C_OPC1.1, DDS.2 (VDD), OP_GAIN.8 (V+), OP_HOWL.8 (V+), OP_S2D.8 (V+); also elsewhere on the board
VOUT: C_VSIN_OUT.1, DDS.10 (VOUT), TP_VSIN.TP
VSIN: C_VSIN_OUT.2, OP_GAIN.3 (POSA)
VSS: C_OPA2.1, C_OPB2.1, C_OPC2.1, OP_GAIN.4 (V-), OP_HOWL.4 (V-), OP_S2D.4 (V-); also elsewhere on the board

Notes on the sheet:
DDS Chip, programmed by SPI
Howland Current Pump Can select between two outputs with different magnitudes
Power Bypass Caps for Op Amps

Board: 2 copper layers, 70.0 x 35.0 mm, 67 parts (36 on the bottom side), 40 nets.

## EAGLE design schematics/Rev.Dec.2016/Parallel CS V5 repeated.brd

Board: 4 copper layers, 99.9 x 150.1 mm, 290 parts (0 on the bottom side), 145 nets.

Parts:
CLOCK: LTC69000; SOT23-5L
C_CLK_BYP: 0.1u; C0805
C_DDS1, C_DDS5, C_DDS9, C_DDS13, C_DDS17, C_DDS21: 0.1u; C0805
C_DDS2, C_DDS6, C_DDS10, C_DDS14, C_DDS18, C_DDS22: 10u; C0805
C_DDS3, C_DDS7, C_DDS11, C_DDS15, C_DDS19, C_DDS23: 10n; C0805
C_DDS4, C_DDS8, C_DDS12, C_DDS16, C_DDS20, C_DDS24: 100n; C0805
C_DECOUP, C_DECOUP1, C_DECOUP2, C_DECOUP3, C_DECOUP4, C_DECOUP5: 1u; C0805
C_OPA1, C_OPA2, C_OPA3, C_OPA4, C_OPA5, C_OPA6, C_OPA7, C_OPA8, C_OPA9, C_OPA10, C_OPA11, C_OPA12: 0.1u; C0805
C_OPB1, C_OPB2, C_OPB3, C_OPB4, C_OPB5, C_OPB6, C_OPB7, C_OPB8, C_OPB9, C_OPB10, C_OPB11, C_OPB12: 0.1u; C0805
C_OPC1, C_OPC2, C_OPC3, C_OPC4, C_OPC5, C_OPC6, C_OPC7, C_OPC8, C_OPC9, C_OPC10, C_OPC11, C_OPC12: 0.1u; C0805
C_OPD1, C_OPD2, C_OPD3, C_OPD4, C_OPD5, C_OPD6, C_OPD7, C_OPD8, C_OPD9, C_OPD10, C_OPD11, C_OPD12: 0.1u; C0805
DDS, DDS1, DDS2, DDS3, DDS4, DDS5: AD9833BRMZ; SOP50P490X110-10N
JP+: PWR; JST-2-SMD
JP-: PWR; JST-2-SMD
JP_OUT, JP_OUT1, JP_OUT2, JP_OUT3, JP_OUT4, JP_OUT5: JP1
LED_VDD: SML0805
LED_VSS: SML0805
OP_GAIN, OP_GAIN1, OP_GAIN2, OP_GAIN3, OP_GAIN4, OP_GAIN5: RC4560SOP65; SOP65P490X109-8N
OP_HOWLA, OP_HOWLA1, OP_HOWLA2, OP_HOWLA3, OP_HOWLA4, OP_HOWLA5: RC4560SOP65; SOP65P490X109-8N
OP_HOWLB, OP_HOWLB1, OP_HOWLB2, OP_HOWLB3, OP_HOWLB4, OP_HOWLB5: RC4560SOP65; SOP65P490X109-8N
OP_S2D, OP_S2D1, OP_S2D2, OP_S2D3, OP_S2D4, OP_S2D5: RC4560SOP65; SOP65P490X109-8N
R1, R3, R5, R7, R9, R10, R11: 10k; R0805
R2, R4, R6, R8, R12, R13: 20k; R0805
R_DECOUP, R_DECOUP1, R_DECOUP2, R_DECOUP3, R_DECOUP4, R_DECOUP5: 10k; R0805
R_GAIN1, R_GAIN3, R_GAIN5, R_GAIN7, R_GAIN9, R_GAIN11: 10k; R0805
R_GAIN2, R_GAIN4, R_GAIN6, R_GAIN8, R_GAIN10, R_GAIN12: 1; R0805
R_GAINF, R_GAINF1, R_GAINF2, R_GAINF3, R_GAINF4, R_GAINF5: PT-10
R_HOWA1, R_HOWA2, R_HOWA3, R_HOWA4, R_HOWA6, R_HOWA7, R_HOWA8, R_HOWA9, R_HOWA11, R_HOWA12, R_HOWA13, R_HOWA14, R_HOWA16, R_HOWA17, R_HOWA18, R_HOWA19, R_HOWA21, R_HOWA22, R_HOWA23, R_HOWA24, R_HOWA26, R_HOWA27, R_HOWA28, R_HOWA29: 100k; R0805
R_HOWA5, R_HOWA10, R_HOWA15, R_HOWA20, R_HOWA25, R_HOWA30: 10k; R0805
R_HOWB1, R_HOWB2, R_HOWB3, R_HOWB5, R_HOWB6, R_HOWB7, R_HOWB9, R_HOWB10, R_HOWB11, R_HOWB12, R_HOWB14, R_HOWB15, R_HOWB16, R_HOWB17, R_HOWB19, R_HOWB20, R_HOWB21, R_HOWB22, R_HOWB24, R_HOWB25, R_HOWB26, R_HOWB27, R_HOWB29, R_HOWB30: 100k; R0805
R_HOWB4, R_HOWB8, R_HOWB13, R_HOWB18, R_HOWB23, R_HOWB28: 10k; R0805
R_PULLDOWN, R_PULLDOWN1, R_PULLDOWN2, R_PULLDOWN3, R_PULLDOWN4, R_PULLDOWN5: 20k; R0805
R_S2D1, R_S2D2, R_S2D3, R_S2D4, R_S2D5, R_S2D6, R_S2D7, R_S2D8, R_S2D9, R_S2D10, R_S2D11, R_S2D12, R_S2D13, R_S2D14, R_S2D15, R_S2D16, R_S2D17, R_S2D18, R_S2D19, R_S2D20, R_S2D21, R_S2D22, R_S2D23, R_S2D24: 10k; R0805
R_SET: 20k; R0805
R_VDD_LED: 1k; M0805
R_VSS_LED: 1k; M0805
S1, S2: PVA1F
TP_FSYNC, TP_FSYNC1, TP_FSYNC2, TP_FSYNC3, TP_FSYNC4, TP_FSYNC5: PTR1PAD1-13; P1-13
TP_GND: PTR1PAD1-13; P1-13
TP_MCLK: PTR1PAD1-13; P1-13
TP_SCLK: PTR1PAD1-13; P1-13
TP_SDATA: PTR1PAD1-13; P1-13
TP_VDD: PTR1PAD1-13; P1-13
TP_VSIN, TP_VSIN1, TP_VSIN2, TP_VSIN3, TP_VSIN4, TP_VSIN5, TP_VSIN6, TP_VSIN7, TP_VSIN8, TP_VSIN9, TP_VSIN10, TP_VSIN11, TP_VSIN12, TP_VSIN13, TP_VSIN14, TP_VSIN15, TP_VSIN16, TP_VSIN17, TP_VSIN18, TP_VSIN19, TP_VSIN20, TP_VSIN21, TP_VSIN22, TP_VSIN23: PTR1PAD1-13; P1-13
TP_VSS: PTR1PAD1-13; P1-13
U1: ADG714BRUZ; SOP65P640X120-24N
U$1: NANO

Connections:
CLK_OUT: CLOCK.5, DDS.5, DDS1.5, DDS2.5, DDS3.5, DDS4.5, DDS5.5, TP_MCLK.TP
COMP: C_DDS3.2, DDS.1
COMP1: C_DDS7.2, DDS1.1
COMP2: C_DDS11.2, DDS2.1
COMP3: C_DDS15.2, DDS3.1
COMP4: C_DDS19.2, DDS4.1
COMP5: C_DDS23.2, DDS5.1
DDS_SCLK: DDS.7, DDS1.7, DDS2.7, DDS3.7, DDS4.7, DDS5.7, R1.1, R2.2, TP_SCLK.TP
DDS_SCLK_5V: R1.2, U$1.D13
DDS_SDATA: DDS.6, DDS1.6, DDS2.6, DDS3.6, DDS4.6, DDS5.6, R3.1, R4.2, TP_SDATA.TP
FSYNC_CS1: DDS.8, R_PULLDOWN.2, TP_FSYNC.TP, U1.6
FSYNC_CS2: DDS1.8, R_PULLDOWN1.2, TP_FSYNC1.TP, U1.8
FSYNC_CS3: DDS2.8, R_PULLDOWN2.2, TP_FSYNC2.TP, U1.10
FSYNC_CS4: DDS3.8, R_PULLDOWN3.2, TP_FSYNC3.TP, U1.12
FSYNC_CS5: DDS4.8, R_PULLDOWN4.2, TP_FSYNC4.TP, U1.13
FSYNC_CS6: DDS5.8, R_PULLDOWN5.2, TP_FSYNC5.TP, U1.15
FSYNC_IN: R11.2, U1.5, U1.7, U1.9, U1.11, U1.14, U1.16, U1.18, U1.20
FSYNC_IN_5V: R11.1, U$1.D5
GND: CLOCK.2, CLOCK.4, C_CLK_BYP.2, C_DDS1.2, C_DDS2.2, C_DDS4.1, C_DDS5.2, C_DDS6.2, C_DDS8.1, C_DDS9.2, C_DDS10.2, C_DDS12.1, C_DDS13.2, C_DDS14.2, C_DDS16.1, C_DDS17.2, C_DDS18.2, C_DDS20.1, C_DDS21.2, C_DDS22.2, C_DDS24.1, C_OPA1.2, C_OPA2.2, C_OPA3.2, C_OPA4.2, C_OPA5.2, C_OPA6.2, C_OPA7.2, C_OPA8.2, C_OPA9.2, C_OPA10.2, C_OPA11.2, C_OPA12.2, C_OPB1.2, C_OPB2.2, C_OPB3.2, C_OPB4.2, C_OPB5.2, C_OPB6.2, C_OPB7.2, C_OPB8.2, C_OPB9.2, C_OPB10.2, C_OPB11.2, C_OPB12.2, C_OPC1.2, C_OPC2.2, C_OPC3.2, C_OPC4.2, C_OPC5.2, C_OPC6.2, C_OPC7.2, C_OPC8.2, C_OPC9.2, C_OPC10.2, C_OPC11.2, C_OPC12.2, C_OPD1.2, C_OPD2.2, C_OPD3.2, C_OPD4.2, C_OPD5.2, C_OPD6.2, C_OPD7.2, C_OPD8.2, C_OPD9.2, C_OPD10.2, C_OPD11.2, C_OPD12.2, DDS.4, DDS.9, DDS1.4, DDS1.9, DDS2.4, DDS2.9, DDS3.4, DDS3.9, DDS4.4, DDS4.9, DDS5.4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
unnamed: C_DDS4.2, DDS.3
unnamed: CLOCK.3, R_SET.2
unnamed: OP_GAIN.1, R_GAIN2.1, R_GAINF.3, R_S2D3.2, R_S2D4.2, TP_VSIN1.TP
unnamed: OP_S2D.6, OP_S2D.7, R_HOWA1.2, R_HOWB1.2, TP_VSIN3.TP
unnamed: OP_GAIN.2, R_GAIN1.2, R_GAIN2.2, R_GAINF.1
unnamed: OP_S2D.5, R_S2D4.1
unnamed: OP_HOWLA.5, R_HOWA1.1, R_HOWA3.1
unnamed: OP_S2D.1, R_HOWA2.2, R_HOWB2.2, R_S2D1.1, TP_VSIN2.TP
unnamed: OP_S2D.3, R_S2D2.1
unnamed: OP_S2D.2, R_S2D1.2, R_S2D3.1
unnamed: OP_HOWLB.3, R_HOWB2.1, R_HOWB3.1
unnamed: OP_HOWLB.2, R_HOWB1.1, R_HOWB5.1
unnamed: JP_OUT.2, R_HOWB3.2, R_HOWB4.1
unnamed: JP_OUT.1, R_HOWA3.2, R_HOWA5.2
unnamed: JP+.2, S1.2
unnamed: JP+.1, S1.4
unnamed: OP_HOWLA.7, R_HOWA4.1, R_HOWA5.1
unnamed: JP-.2, S2.2
unnamed: JP-.1, S2.4
unnamed: OP_HOWLA.6, R_HOWA2.1, R_HOWA4.2
unnamed: LED_VDD.A, R_VDD_LED.1
unnamed: LED_VSS.A, R_VSS_LED.1
unnamed: R3.2, U$1.D11
unnamed: OP_HOWLB.1, R_HOWB4.2, R_HOWB5.2
unnamed: C_DDS8.2, DDS1.3
unnamed: OP_GAIN1.1, R_GAIN4.1, R_GAINF1.3, R_S2D7.2, R_S2D8.2, TP_VSIN5.TP
unnamed: OP_GAIN1.2, R_GAIN3.2, R_GAIN4.2, R_GAINF1.1
unnamed: OP_S2D1.5, R_S2D8.1
unnamed: OP_S2D1.1, R_HOWA8.2, R_HOWB6.2, R_S2D5.1, TP_VSIN6.TP
unnamed: OP_S2D1.3, R_S2D6.1
unnamed: OP_S2D1.2, R_S2D5.2, R_S2D7.1
unnamed: OP_HOWLB1.2, R_HOWB7.1, R_HOWB9.1
unnamed: JP_OUT1.1, R_HOWA6.2, R_HOWA10.2
unnamed: OP_HOWLA1.7, R_HOWA9.1, R_HOWA10.1
unnamed: OP_HOWLA1.6, R_HOWA8.1, R_HOWA9.2
unnamed: OP_S2D1.6, OP_S2D1.7, R_HOWA7.2, R_HOWB7.2, TP_VSIN7.TP
unnamed: OP_HOWLB1.3, R_HOWB6.1, R_HOWB10.1
unnamed: OP_HOWLA1.5, R_HOWA6.1, R_HOWA7.1
unnamed: JP_OUT1.2, R_HOWB8.1, R_HOWB10.2
unnamed: OP_HOWLB1.1, R_HOWB8.2, R_HOWB9.2
unnamed: C_DDS12.2, DDS2.3
unnamed: OP_GAIN2.1, R_GAIN6.1, R_GAINF2.3, R_S2D11.2, R_S2D12.2, TP_VSIN9.TP
unnamed: OP_GAIN2.2, R_GAIN5.2, R_GAIN6.2, R_GAINF2.1
unnamed: OP_S2D2.5, R_S2D12.1
unnamed: OP_S2D2.1, R_HOWA13.2, R_HOWB11.2, R_S2D9.1, TP_VSIN10.TP
unnamed: OP_S2D2.3, R_S2D10.1
unnamed: OP_S2D2.2, R_S2D9.2, R_S2D11.1
unnamed: OP_HOWLB2.2, R_HOWB12.1, R_HOWB14.1
unnamed: JP_OUT2.1, R_HOWA11.2, R_HOWA15.2
unnamed: OP_HOWLA2.7, R_HOWA14.1, R_HOWA15.1
unnamed: OP_HOWLA2.6, R_HOWA13.1, R_HOWA14.2
unnamed: OP_S2D2.6, OP_S2D2.7, R_HOWA12.2, R_HOWB12.2, TP_VSIN11.TP
unnamed: OP_HOWLB2.3, R_HOWB11.1, R_HOWB15.1
unnamed: OP_HOWLA2.5, R_HOWA11.1, R_HOWA12.1
unnamed: JP_OUT2.2, R_HOWB13.1, R_HOWB15.2
unnamed: OP_HOWLB2.1, R_HOWB13.2, R_HOWB14.2
unnamed: C_DDS16.2, DDS3.3
unnamed: OP_GAIN3.1, R_GAIN8.1, R_GAINF3.3, R_S2D15.2, R_S2D16.2, TP_VSIN13.TP
unnamed: OP_GAIN3.2, R_GAIN7.2, R_GAIN8.2, R_GAINF3.1
unnamed: OP_S2D3.5, R_S2D16.1
unnamed: OP_S2D3.1, R_HOWA18.2, R_HOWB16.2, R_S2D13.1, TP_VSIN14.TP
unnamed: OP_S2D3.3, R_S2D14.1
unnamed: OP_S2D3.2, R_S2D13.2, R_S2D15.1
unnamed: OP_HOWLB3.2, R_HOWB17.1, R_HOWB19.1
unnamed: JP_OUT3.1, R_HOWA16.2, R_HOWA20.2
unnamed: OP_HOWLA3.7, R_HOWA19.1, R_HOWA20.1
unnamed: OP_HOWLA3.6, R_HOWA18.1, R_HOWA19.2
unnamed: OP_S2D3.6, OP_S2D3.7, R_HOWA17.2, R_HOWB17.2, TP_VSIN15.TP
unnamed: OP_HOWLB3.3, R_HOWB16.1, R_HOWB20.1
unnamed: OP_HOWLA3.5, R_HOWA16.1, R_HOWA17.1
unnamed: JP_OUT3.2, R_HOWB18.1, R_HOWB20.2
unnamed: OP_HOWLB3.1, R_HOWB18.2, R_HOWB19.2
unnamed: C_DDS20.2, DDS4.3
unnamed: OP_GAIN4.1, R_GAIN10.1, R_GAINF4.3, R_S2D19.2, R_S2D20.2, TP_VSIN17.TP
unnamed: OP_GAIN4.2, R_GAIN9.2, R_GAIN10.2, R_GAINF4.1
unnamed: OP_S2D4.5, R_S2D20.1
unnamed: OP_S2D4.1, R_HOWA23.2, R_HOWB21.2, R_S2D17.1, TP_VSIN18.TP
unnamed: OP_S2D4.3, R_S2D18.1
unnamed: OP_S2D4.2, R_S2D17.2, R_S2D19.1
unnamed: OP_HOWLB4.2, R_HOWB22.1, R_HOWB24.1
unnamed: JP_OUT4.1, R_HOWA21.2, R_HOWA25.2
unnamed: OP_HOWLA4.7, R_HOWA24.1, R_HOWA25.1
unnamed: OP_HOWLA4.6, R_HOWA23.1, R_HOWA24.2
unnamed: OP_S2D4.6, OP_S2D4.7, R_HOWA22.2, R_HOWB22.2, TP_VSIN19.TP
unnamed: OP_HOWLB4.3, R_HOWB21.1, R_HOWB25.1
unnamed: OP_HOWLA4.5, R_HOWA21.1, R_HOWA22.1
unnamed: JP_OUT4.2, R_HOWB23.1, R_HOWB25.2
unnamed: OP_HOWLB4.1, R_HOWB23.2, R_HOWB24.2
unnamed: C_DDS24.2, DDS5.3
unnamed: OP_GAIN5.1, R_GAIN12.1, R_GAINF5.3, R_S2D23.2, R_S2D24.2, TP_VSIN21.TP
unnamed: OP_GAIN5.2, R_GAIN11.2, R_GAIN12.2, R_GAINF5.1
unnamed: OP_S2D5.5, R_S2D24.1
unnamed: OP_S2D5.1, R_HOWA28.2, R_HOWB26.2, R_S2D21.1, TP_VSIN22.TP
unnamed: OP_S2D5.3, R_S2D22.1
unnamed: OP_S2D5.2, R_S2D21.2, R_S2D23.1
unnamed: OP_HOWLB5.2, R_HOWB27.1, R_HOWB29.1
unnamed: JP_OUT5.1, R_HOWA26.2, R_HOWA30.2
unnamed: OP_HOWLA5.7, R_HOWA29.1, R_HOWA30.1
unnamed: OP_HOWLA5.6, R_HOWA28.1, R_HOWA29.2
unnamed: OP_S2D5.6, OP_S2D5.7, R_HOWA27.2, R_HOWB27.2, TP_VSIN23.TP
unnamed: OP_HOWLB5.3, R_HOWB26.1, R_HOWB30.1
unnamed: OP_HOWLA5.5, R_HOWA26.1, R_HOWA27.1
unnamed: JP_OUT5.2, R_HOWB28.1, R_HOWB30.2
unnamed: OP_HOWLB5.1, R_HOWB28.2, R_HOWB29.2
SW_DIN: R7.2, R8.1, U1.3
SW_DIN_5V: R7.1, U$1.D4
SW_SCLK: R5.2, R6.1, U1.1
SW_SCLK_5V: R5.1, U$1.D9
SW_~RESET: R10.2, R13.2, U1.23
SW_~RESET_5V: R10.1, U$1.D3
SW_~SYNC: R9.2, R12.2, U1.24
SW_~SYNC_5V: R9.1, U$1.D2
VDD: CLOCK.1, C_CLK_BYP.1, C_DDS1.1, C_DDS2.1, C_DDS3.1, C_DDS5.1, C_DDS6.1, C_DDS7.1, C_DDS9.1, C_DDS10.1, C_DDS11.1, C_DDS13.1, C_DDS14.1, C_DDS15.1, C_DDS17.1, C_DDS18.1, C_DDS19.1, C_DDS21.1, C_DDS22.1, C_DDS23.1, C_OPA1.1, C_OPA3.1, C_OPA5.1, C_OPA7.1, C_OPA9.1, C_OPA11.1, C_OPB1.1, C_OPB3.1, C_OPB5.1, C_OPB7.1, C_OPB9.1, C_OPB11.1, C_OPC1.1, C_OPC3.1, C_OPC5.1, C_OPC7.1, C_OPC9.1, C_OPC11.1, C_OPD1.1, C_OPD3.1, C_OPD5.1, C_OPD7.1, C_OPD9.1, C_OPD11.1, DDS.2, DDS1.2, DDS2.2, DDS3.2, DDS4.2, DDS5.2, OP_GAIN.8, OP_GAIN1.8, OP_GAIN2.8, OP_GAIN3.8, OP_GAIN4.8, OP_GAIN5.8, OP_HOWLA.8, OP_HOWLA1.8, OP_HOWLA2.8, OP_HOWLA3.8, OP_HOWLA4.8, OP_HOWLA5.8, OP_HOWLB.8, OP_HOWLB1.8, OP_HOWLB2.8, OP_HOWLB3.8, OP_HOWLB4.8, OP_HOWLB5.8, OP_S2D.8, OP_S2D1.8, OP_S2D2.8, OP_S2D3.8, OP_S2D4.8, OP_S2D5.8, R_SET.1, R_VDD_LED.2, S1.1, TP_VDD.TP, U1.2
VOUT: C_DECOUP.1, DDS.10, TP_VSIN.TP
VOUT1: C_DECOUP1.1, DDS1.10, TP_VSIN4.TP
VOUT2: C_DECOUP2.1, DDS2.10, TP_VSIN8.TP
VOUT3: C_DECOUP3.1, DDS3.10, TP_VSIN12.TP
VOUT4: C_DECOUP4.1, DDS4.10, TP_VSIN16.TP
VOUT5: C_DECOUP5.1, DDS5.10, TP_VSIN20.TP
VSIN: C_DECOUP.2, OP_GAIN.3, R_DECOUP.1
VSIN1: C_DECOUP1.2, OP_GAIN1.3, R_DECOUP1.1
VSIN2: C_DECOUP2.2, OP_GAIN2.3, R_DECOUP2.1
VSIN3: C_DECOUP3.2, OP_GAIN3.3, R_DECOUP3.1
VSIN4: C_DECOUP4.2, OP_GAIN4.3, R_DECOUP4.1
VSIN5: C_DECOUP5.2, OP_GAIN5.3, R_DECOUP5.1
VSS: C_OPA2.1, C_OPA4.1, C_OPA6.1, C_OPA8.1, C_OPA10.1, C_OPA12.1, C_OPB2.1, C_OPB4.1, C_OPB6.1, C_OPB8.1, C_OPB10.1, C_OPB12.1, C_OPC2.1, C_OPC4.1, C_OPC6.1, C_OPC8.1, C_OPC10.1, C_OPC12.1, C_OPD2.1, C_OPD4.1, C_OPD6.1, C_OPD8.1, C_OPD10.1, C_OPD12.1, OP_GAIN.4, OP_GAIN1.4, OP_GAIN2.4, OP_GAIN3.4, OP_GAIN4.4, OP_GAIN5.4, OP_HOWLA.4, OP_HOWLA1.4, OP_HOWLA2.4, OP_HOWLA3.4, OP_HOWLA4.4, OP_HOWLA5.4, OP_HOWLB.4, OP_HOWLB1.4, OP_HOWLB2.4, OP_HOWLB3.4, OP_HOWLB4.4, OP_HOWLB5.4, OP_S2D.4, OP_S2D1.4, OP_S2D2.4, OP_S2D3.4, OP_S2D4.4, OP_S2D5.4, R_VSS_LED.2, S2.3, TP_VSS.TP
